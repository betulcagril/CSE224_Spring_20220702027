* NGSPICE file created from semi_cpu.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_4 abstract view
.subckt sky130_fd_sc_hd__o32a_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_4 abstract view
.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_2 abstract view
.subckt sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_2 abstract view
.subckt sky130_fd_sc_hd__o311ai_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_2 abstract view
.subckt sky130_fd_sc_hd__o41a_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_2 abstract view
.subckt sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_1 abstract view
.subckt sky130_fd_sc_hd__clkinv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_4 abstract view
.subckt sky130_fd_sc_hd__o31a_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_4 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_2 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_1 abstract view
.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_4 abstract view
.subckt sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4bb_4 abstract view
.subckt sky130_fd_sc_hd__nand4bb_4 A_N B_N C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41ai_2 abstract view
.subckt sky130_fd_sc_hd__o41ai_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4bb_1 abstract view
.subckt sky130_fd_sc_hd__nor4bb_1 A B C_N D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_1 abstract view
.subckt sky130_fd_sc_hd__o32ai_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_1 abstract view
.subckt sky130_fd_sc_hd__a32oi_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_2 abstract view
.subckt sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_4 abstract view
.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

.subckt semi_cpu VGND VPWR an[0] an[1] an[2] an[3] an[4] an[5] an[6] an[7] clk control
+ reset result[0] result[10] result[11] result[12] result[13] result[14] result[15]
+ result[16] result[17] result[18] result[19] result[1] result[20] result[21] result[22]
+ result[23] result[24] result[25] result[26] result[27] result[28] result[29] result[2]
+ result[30] result[31] result[3] result[4] result[5] result[6] result[7] result[8]
+ result[9] seg[0] seg[1] seg[2] seg[3] seg[4] seg[5] seg[6]
XFILLER_0_27_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7963_ _3615_ VGND VGND VPWR VPWR _3616_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_6_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6914_ _2570_ _2565_ _2558_ VGND VGND VPWR VPWR _2571_ sky130_fd_sc_hd__nand3_1
X_7894_ _3542_ _3546_ _3543_ VGND VGND VPWR VPWR _3547_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_64_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6845_ _2398_ _2489_ _0515_ VGND VGND VPWR VPWR _2502_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6776_ _2422_ _2428_ _2429_ _2432_ VGND VGND VPWR VPWR _2433_ sky130_fd_sc_hd__o31a_1
X_8515_ _3996_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_79_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5727_ _1381_ _1382_ _1384_ _1385_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__o211a_1
XFILLER_0_45_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8446_ _4033_ VGND VGND VPWR VPWR _4034_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_60_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5658_ _1310_ _1316_ _1052_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__a21oi_1
X_8377_ _4241_ VGND VGND VPWR VPWR _3997_ sky130_fd_sc_hd__clkbuf_4
X_4609_ _4285_ _0305_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__nor2_1
X_5589_ _1246_ _1236_ _1247_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__a21oi_1
X_7328_ _2394_ _2984_ VGND VGND VPWR VPWR _2985_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7259_ _2915_ _2906_ _2911_ VGND VGND VPWR VPWR _2916_ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_79_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4960_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_106_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4891_ net65 _0527_ _0569_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6630_ _2195_ _2203_ _2215_ _2216_ VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_73_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6561_ _2115_ _2118_ VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8300_ net32 net21 _3790_ _3952_ VGND VGND VPWR VPWR _3953_ sky130_fd_sc_hd__o211a_1
XFILLER_0_89_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5512_ _0627_ _1151_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__xnor2_1
X_6492_ _2046_ _2150_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_42_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8231_ _3883_ VGND VGND VPWR VPWR _3884_ sky130_fd_sc_hd__inv_2
XFILLER_0_14_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5443_ _1100_ _1101_ _1005_ _1031_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__a211o_1
X_8162_ _3775_ _3814_ _3748_ VGND VGND VPWR VPWR _3815_ sky130_fd_sc_hd__a21o_1
X_5374_ _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_74_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7113_ _2733_ _2744_ _2741_ _2769_ VGND VGND VPWR VPWR _2770_ sky130_fd_sc_hd__a31o_1
X_8093_ _2296_ _2343_ _2346_ _2384_ VGND VGND VPWR VPWR _3746_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_10_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7044_ _0954_ _2390_ VGND VGND VPWR VPWR _2701_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7946_ _3587_ _3590_ _3598_ VGND VGND VPWR VPWR _3599_ sky130_fd_sc_hd__o21a_1
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7877_ _3520_ _3529_ _3521_ VGND VGND VPWR VPWR _3530_ sky130_fd_sc_hd__o21a_1
XFILLER_0_92_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6828_ _2398_ _2484_ VGND VGND VPWR VPWR _2485_ sky130_fd_sc_hd__or2_1
XFILLER_0_37_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6759_ _2411_ _2412_ _2415_ VGND VGND VPWR VPWR _2416_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_5_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8429_ _4024_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
Xhold170 rf.registers\[25\]\[12\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold192 rf.registers\[25\]\[19\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
Xhold181 rf.registers\[10\]\[29\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5090_ _0653_ _0655_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__or3_1
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7800_ _3443_ _3452_ _3439_ VGND VGND VPWR VPWR _3453_ sky130_fd_sc_hd__mux2_1
X_8780_ clknet_4_6_0_clk _0154_ _0053_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dfrtp_1
X_5992_ net74 _1636_ _1649_ _1650_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__a31o_2
XPHY_EDGE_ROW_96_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4943_ _0231_ _0511_ _0608_ _0550_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__a22o_1
X_7731_ _3117_ _2420_ _3152_ _3328_ VGND VGND VPWR VPWR _3384_ sky130_fd_sc_hd__a22o_1
X_7662_ _0591_ _3313_ _3308_ _3315_ VGND VGND VPWR VPWR _3317_ sky130_fd_sc_hd__a31o_1
X_6613_ _2203_ _2270_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__xnor2_1
X_4874_ net17 VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_15_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7593_ _3242_ _3245_ _3247_ VGND VGND VPWR VPWR _3248_ sky130_fd_sc_hd__o21a_1
X_6544_ _2201_ _2202_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__nor2b_2
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_6_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6475_ _2055_ _2040_ _2133_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__or3_1
X_8214_ _3856_ net49 _3722_ _3725_ _3727_ VGND VGND VPWR VPWR _3867_ sky130_fd_sc_hd__o41a_1
XFILLER_0_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5426_ _0971_ _1052_ _0980_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__or3b_2
XFILLER_0_2_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8145_ net21 _3342_ _3789_ _3797_ VGND VGND VPWR VPWR _3798_ sky130_fd_sc_hd__o2bb2a_1
X_5357_ _0919_ _0961_ _1013_ _1015_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__a22o_1
X_8076_ _2302_ _3717_ VGND VGND VPWR VPWR _3729_ sky130_fd_sc_hd__xnor2_1
X_5288_ _0860_ _0946_ _0940_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__mux2_4
X_7027_ _2642_ _2643_ VGND VGND VPWR VPWR _2684_ sky130_fd_sc_hd__or2_1
XFILLER_0_69_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7929_ _3348_ _1822_ _3329_ _3581_ VGND VGND VPWR VPWR _3582_ sky130_fd_sc_hd__a211o_1
XFILLER_0_92_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4590_ _4316_ _4318_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6260_ _1918_ _1774_ _1909_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_71_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6191_ net90 _1837_ _1848_ _1849_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__a22o_1
X_5211_ _0866_ _0869_ _0855_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__mux2_4
X_5142_ _0758_ _0748_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__and2_1
X_5073_ _0686_ _0730_ _0690_ _0731_ _0625_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__o32a_4
XFILLER_0_79_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8832_ clknet_4_8_0_clk _0206_ VGND VGND VPWR VPWR rf.registers\[5\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8763_ clknet_4_13_0_clk _0137_ _0036_ VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_19_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5975_ _1633_ _1467_ _1504_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__o21bai_1
X_4926_ _0265_ _0247_ _0264_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__or3_1
X_8694_ clknet_4_15_0_clk _0068_ VGND VGND VPWR VPWR rf.registers\[25\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_7714_ _3118_ _2741_ VGND VGND VPWR VPWR _3367_ sky130_fd_sc_hd__nand2_1
X_7645_ _0587_ _3299_ VGND VGND VPWR VPWR _3300_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4857_ _4289_ _0304_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__and2b_1
XFILLER_0_7_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7576_ net64 _3230_ VGND VGND VPWR VPWR _3231_ sky130_fd_sc_hd__or2_1
XFILLER_0_105_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6527_ _2185_ _1994_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4788_ net28 VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__buf_4
X_6458_ _2103_ _2116_ _2102_ _2075_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_30_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6389_ net114 net105 _1972_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__a21boi_1
X_5409_ _0975_ _1067_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8128_ _3772_ _3780_ VGND VGND VPWR VPWR _3781_ sky130_fd_sc_hd__nand2_1
X_8059_ net9 _2300_ VGND VGND VPWR VPWR _3712_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5760_ _1393_ _1391_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__or2b_4
X_4711_ _4278_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5691_ _1349_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__inv_2
X_7430_ _3084_ _3058_ _3085_ _3086_ VGND VGND VPWR VPWR _3087_ sky130_fd_sc_hd__a211o_1
X_4642_ _4186_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_60_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4573_ _0227_ _0229_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__or2_1
X_7361_ _2917_ VGND VGND VPWR VPWR _3018_ sky130_fd_sc_hd__buf_2
XFILLER_0_71_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6312_ _1597_ _1904_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__xnor2_1
X_7292_ _2934_ _2930_ _2939_ VGND VGND VPWR VPWR _2949_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6243_ _1758_ _1884_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__and2_1
X_6174_ _1799_ _1827_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__xnor2_1
X_5125_ _0626_ _0783_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5056_ net27 _0714_ _0679_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8815_ clknet_4_7_0_clk _0189_ VGND VGND VPWR VPWR rf.registers\[10\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_8746_ clknet_4_0_0_clk _0120_ VGND VGND VPWR VPWR rf.registers\[15\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5958_ _1439_ _1616_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__xnor2_2
X_4909_ net40 _4156_ _0582_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5889_ _1442_ _1535_ _1441_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__o21ba_1
X_8677_ net166 _4130_ VGND VGND VPWR VPWR _4140_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7628_ net40 _3282_ VGND VGND VPWR VPWR _3283_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7559_ _3208_ VGND VGND VPWR VPWR _3214_ sky130_fd_sc_hd__inv_2
XFILLER_0_43_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold74 rf.registers\[5\]\[4\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold63 _3975_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 display.refresh_counter\[2\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold85 rf.registers\[15\]\[14\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold96 rf.registers\[10\]\[24\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_60_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer17 _3957_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer39 _3812_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_1
Xrebuffer28 _3726_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_65_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6930_ _2539_ _2558_ _2586_ VGND VGND VPWR VPWR _2587_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_37_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6861_ _2493_ _2497_ _2515_ _2517_ VGND VGND VPWR VPWR _2518_ sky130_fd_sc_hd__a31o_1
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6792_ _2433_ _2446_ _2447_ _2448_ VGND VGND VPWR VPWR _2449_ sky130_fd_sc_hd__o211a_1
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5812_ _1470_ _1459_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__xnor2_1
X_8600_ _4099_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5743_ _1362_ _1367_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__nand2_1
X_8531_ _4070_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8462_ _4042_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
X_5674_ _1331_ net54 _1332_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__a21boi_4
X_7413_ _3018_ _3059_ VGND VGND VPWR VPWR _3070_ sky130_fd_sc_hd__nand2_1
X_8393_ _4005_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4625_ _4255_ _0320_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_102_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4556_ _4186_ _4189_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__xnor2_1
X_7344_ _2978_ _3000_ VGND VGND VPWR VPWR _3001_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_77_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4487_ _4218_ _4295_ VGND VGND VPWR VPWR _4296_ sky130_fd_sc_hd__xor2_1
X_7275_ _2889_ _2911_ VGND VGND VPWR VPWR _2932_ sky130_fd_sc_hd__or2b_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6226_ _1882_ _1758_ _1884_ _1791_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6157_ _1684_ _1811_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__xor2_1
X_5108_ _0625_ _0766_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__nor2_1
X_6088_ _1625_ net83 _1700_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__nand3_1
X_5039_ _0505_ _0697_ _0679_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8729_ clknet_4_9_0_clk _0103_ VGND VGND VPWR VPWR rf.registers\[15\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput7 net7 VGND VGND VPWR VPWR an[5] sky130_fd_sc_hd__clkbuf_4
Xoutput42 net42 VGND VGND VPWR VPWR seg[0] sky130_fd_sc_hd__clkbuf_4
Xoutput31 net31 VGND VGND VPWR VPWR result[29] sky130_fd_sc_hd__buf_2
Xoutput20 net20 VGND VGND VPWR VPWR result[19] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_62_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4410_ rf.registers\[5\]\[16\] _4148_ _4174_ rf.registers\[15\]\[16\] VGND VGND VPWR
+ VPWR _4219_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5390_ _1005_ _1031_ _0959_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__o21a_1
XFILLER_0_22_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4341_ _4149_ VGND VGND VPWR VPWR _4150_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7060_ _2685_ _2686_ VGND VGND VPWR VPWR _2717_ sky130_fd_sc_hd__or2_1
X_6011_ _1329_ _1552_ _1558_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_94_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7962_ _3614_ _3340_ VGND VGND VPWR VPWR _3615_ sky130_fd_sc_hd__or2_1
X_6913_ _2523_ _2525_ VGND VGND VPWR VPWR _2570_ sky130_fd_sc_hd__nor2_1
X_7893_ _3542_ _3543_ _3544_ _3545_ VGND VGND VPWR VPWR _3546_ sky130_fd_sc_hd__o211a_1
XFILLER_0_49_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6844_ _2499_ _2500_ _2398_ VGND VGND VPWR VPWR _2501_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_9_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6775_ _2387_ _2430_ _2431_ VGND VGND VPWR VPWR _2432_ sky130_fd_sc_hd__or3_4
X_8514_ _3996_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5726_ _0726_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__buf_4
XFILLER_0_45_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8445_ _4143_ _4155_ _4032_ imem.address\[0\] VGND VGND VPWR VPWR _4033_ sky130_fd_sc_hd__or4b_4
XTAP_TAPCELL_ROW_79_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5657_ _1311_ _1314_ _1315_ _1258_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__a211o_1
X_8376_ _3996_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__inv_2
X_4608_ _4289_ _0303_ _0304_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5588_ _0628_ _1229_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__and2_1
X_4539_ _0234_ _0235_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__or2b_1
X_7327_ _2982_ _2983_ _2968_ VGND VGND VPWR VPWR _2984_ sky130_fd_sc_hd__mux2_1
X_7258_ _2907_ net52 _2908_ VGND VGND VPWR VPWR _2915_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_7_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6209_ _1865_ _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__xnor2_1
X_7189_ _2392_ _2845_ VGND VGND VPWR VPWR _2846_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4890_ _0550_ _0567_ _0568_ _0469_ _0446_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__a32o_1
XFILLER_0_80_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6560_ _2167_ _2176_ _2182_ _2217_ _2218_ VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__a221o_2
XFILLER_0_13_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5511_ _0952_ _1166_ _1169_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__o21ba_1
X_6491_ _1679_ _2049_ _2131_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__a21o_1
XFILLER_0_54_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8230_ _3671_ _3672_ VGND VGND VPWR VPWR _3883_ sky130_fd_sc_hd__nand2_1
X_5442_ _1011_ _1017_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8161_ _3753_ _3813_ VGND VGND VPWR VPWR _3814_ sky130_fd_sc_hd__or2_4
X_5373_ _1031_ _1005_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__nor2_4
X_8092_ _3742_ _3744_ VGND VGND VPWR VPWR _3745_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_74_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7112_ _2721_ _2768_ VGND VGND VPWR VPWR _2769_ sky130_fd_sc_hd__nand2_1
X_7043_ _2696_ _2698_ _2699_ VGND VGND VPWR VPWR _2700_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7945_ _3586_ _3597_ VGND VGND VPWR VPWR _3598_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_85_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7876_ _3519_ _3523_ VGND VGND VPWR VPWR _3529_ sky130_fd_sc_hd__nor2_1
X_6827_ _2440_ _2433_ _2458_ VGND VGND VPWR VPWR _2484_ sky130_fd_sc_hd__and3b_1
XFILLER_0_92_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6758_ _0468_ _2409_ _2413_ _2414_ _0673_ VGND VGND VPWR VPWR _2415_ sky130_fd_sc_hd__o2111a_2
X_6689_ _2227_ _2296_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5709_ _1265_ _1277_ _0629_ _1274_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8428_ net228 _0514_ _4019_ VGND VGND VPWR VPWR _4024_ sky130_fd_sc_hd__mux2_1
X_8359_ net127 _3986_ VGND VGND VPWR VPWR _3989_ sky130_fd_sc_hd__nor2_1
Xhold171 rf.registers\[15\]\[1\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
Xhold160 rf.registers\[10\]\[15\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 rf.registers\[10\]\[17\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
Xhold193 display.refresh_counter\[13\] VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5991_ _1461_ _1569_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__nor2_1
X_4942_ _0256_ _0403_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__or2_1
X_7730_ _0515_ _3382_ _3333_ VGND VGND VPWR VPWR _3383_ sky130_fd_sc_hd__mux2_1
X_7661_ _3305_ _3315_ VGND VGND VPWR VPWR _3316_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6612_ _2195_ _2215_ _2193_ VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__a21o_1
X_4873_ net63 _0527_ _0555_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__a21o_1
X_7592_ _3234_ _3236_ _3246_ VGND VGND VPWR VPWR _3247_ sky130_fd_sc_hd__a21o_1
XFILLER_0_104_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6543_ _0639_ _2196_ _2200_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__nand3_1
XFILLER_0_70_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6474_ _2034_ _2132_ VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8213_ _3717_ VGND VGND VPWR VPWR _3866_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5425_ _0634_ _1078_ _1080_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__or3_1
XFILLER_0_42_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_549 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8144_ _3329_ _3796_ _3342_ VGND VGND VPWR VPWR _3797_ sky130_fd_sc_hd__a21o_1
X_5356_ _1014_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__inv_2
X_8075_ _2287_ net102 VGND VGND VPWR VPWR _3728_ sky130_fd_sc_hd__xnor2_1
X_5287_ _0861_ _0902_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__xnor2_1
X_7026_ _2644_ _2646_ _2668_ VGND VGND VPWR VPWR _2683_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7928_ _3348_ _3000_ VGND VGND VPWR VPWR _3581_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7859_ _3509_ _3511_ VGND VGND VPWR VPWR _3512_ sky130_fd_sc_hd__or2b_1
XFILLER_0_18_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_103_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5210_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__inv_2
X_6190_ _0620_ _1846_ _1708_ _1709_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_71_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5141_ _0616_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__buf_6
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5072_ _0428_ _0687_ net33 VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__o21a_1
X_8831_ clknet_4_8_0_clk _0205_ VGND VGND VPWR VPWR rf.registers\[5\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8762_ clknet_4_13_0_clk _0136_ _0035_ VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__dfrtp_2
XTAP_TAPCELL_ROW_82_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5974_ _1483_ _1501_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__nand2_1
X_7713_ net65 net2 _3365_ VGND VGND VPWR VPWR _3366_ sky130_fd_sc_hd__o21ai_1
X_4925_ net36 VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__buf_6
X_8693_ clknet_4_15_0_clk _0067_ VGND VGND VPWR VPWR rf.registers\[25\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_7644_ _3297_ _3298_ VGND VGND VPWR VPWR _3299_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4856_ _4200_ _0471_ _0475_ _0518_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__o22a_1
XFILLER_0_7_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7575_ _3226_ _3229_ VGND VGND VPWR VPWR _3230_ sky130_fd_sc_hd__nor2_1
X_6526_ _2071_ _2183_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__nor2_1
X_4787_ _0468_ _4157_ _0479_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6457_ _1980_ _2070_ _2076_ _2101_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__a31oi_1
X_6388_ _2034_ _2040_ _2046_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__nand3_1
X_5408_ _0956_ _0960_ _0970_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__o21a_1
X_8127_ net9 _3740_ VGND VGND VPWR VPWR _3780_ sky130_fd_sc_hd__nand2_1
X_5339_ _0996_ _0993_ _0997_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__o21a_1
X_8058_ net72 _2309_ VGND VGND VPWR VPWR _3711_ sky130_fd_sc_hd__nor2_1
X_7009_ _2635_ _2636_ _2665_ VGND VGND VPWR VPWR _2666_ sky130_fd_sc_hd__a21o_1
XFILLER_0_97_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_88_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4710_ _0398_ _0405_ _4199_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5690_ _1229_ _1348_ _1334_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__mux2_4
XFILLER_0_44_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4641_ _4316_ _0337_ _0335_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4572_ _0242_ _0266_ _0268_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__a21o_1
X_7360_ _3002_ _3005_ _3013_ VGND VGND VPWR VPWR _3017_ sky130_fd_sc_hd__or3_1
XFILLER_0_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6311_ _1597_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__clkbuf_4
X_7291_ _1843_ _2947_ _2945_ VGND VGND VPWR VPWR _2948_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6242_ _1899_ _1900_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6173_ _1695_ _1822_ _1830_ _1831_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__a2bb2o_1
X_5124_ _0689_ _0782_ net101 VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__mux2_1
X_5055_ _0664_ _0669_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_68_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8814_ clknet_4_7_0_clk _0188_ VGND VGND VPWR VPWR rf.registers\[10\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5957_ _1515_ _1615_ _1568_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__mux2_4
X_8745_ clknet_4_2_0_clk _0119_ VGND VGND VPWR VPWR rf.registers\[15\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4908_ _0550_ _0277_ _0581_ _0512_ _0469_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__a32o_1
X_8676_ _4139_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7627_ net67 _3275_ _3277_ _3281_ VGND VGND VPWR VPWR _3282_ sky130_fd_sc_hd__a31o_1
X_5888_ _1484_ _1538_ _1543_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_47_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4839_ net24 _4157_ _0526_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7558_ _3210_ _3212_ VGND VGND VPWR VPWR _3213_ sky130_fd_sc_hd__nor2_1
X_6509_ _2013_ _2163_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__or2b_1
X_7489_ _3140_ VGND VGND VPWR VPWR _3144_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_91_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold64 display.refresh_counter\[3\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 _3971_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 rf.registers\[10\]\[6\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 rf.registers\[5\]\[14\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold97 rf.registers\[15\]\[24\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_100_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrebuffer18 _3955_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__buf_2
XFILLER_0_83_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer29 _2383_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__buf_12
XTAP_TAPCELL_ROW_65_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6860_ _2484_ _2516_ _2489_ VGND VGND VPWR VPWR _2517_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6791_ _2422_ _2428_ _2429_ _2432_ _0494_ VGND VGND VPWR VPWR _2448_ sky130_fd_sc_hd__o311ai_2
X_5811_ _1418_ _1371_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5742_ _1362_ _1367_ _1396_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__a31o_1
X_8530_ _4070_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__inv_2
XFILLER_0_29_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8461_ net190 _4034_ VGND VGND VPWR VPWR _4042_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5673_ _1104_ _1317_ _1318_ _1323_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__o31a_1
X_7412_ net37 _3018_ VGND VGND VPWR VPWR _3069_ sky130_fd_sc_hd__nand2_1
X_8392_ net233 _0586_ _3997_ VGND VGND VPWR VPWR _4005_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4624_ _4248_ _4251_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__xnor2_1
X_4555_ rf.registers\[25\]\[1\] _4164_ _4171_ rf.registers\[10\]\[1\] VGND VGND VPWR
+ VPWR _0252_ sky130_fd_sc_hd__a22o_1
X_7343_ _2996_ _2999_ VGND VGND VPWR VPWR _3000_ sky130_fd_sc_hd__nor2_2
XFILLER_0_12_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_77_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4486_ _4214_ _4219_ _4294_ VGND VGND VPWR VPWR _4295_ sky130_fd_sc_hd__or3_1
X_7274_ _2899_ _2901_ _2902_ _2890_ VGND VGND VPWR VPWR _2931_ sky130_fd_sc_hd__o31a_1
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6225_ _1726_ _1732_ _1781_ _1883_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__o31ai_2
X_6156_ _1809_ _1810_ _1813_ _1814_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__and4bb_1
X_5107_ _0698_ _0765_ _0736_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__mux2_1
X_6087_ _1676_ _1745_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5038_ _0693_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_0_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8728_ clknet_4_8_0_clk _0102_ VGND VGND VPWR VPWR rf.registers\[15\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_6989_ _2645_ _2642_ VGND VGND VPWR VPWR _2646_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_90_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8659_ net169 _4130_ VGND VGND VPWR VPWR _4131_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput43 net43 VGND VGND VPWR VPWR seg[1] sky130_fd_sc_hd__buf_6
Xoutput10 net10 VGND VGND VPWR VPWR result[0] sky130_fd_sc_hd__clkbuf_4
Xoutput32 net32 VGND VGND VPWR VPWR result[2] sky130_fd_sc_hd__clkbuf_4
Xoutput21 net21 VGND VGND VPWR VPWR result[1] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_8_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput8 net8 VGND VGND VPWR VPWR an[6] sky130_fd_sc_hd__buf_2
XFILLER_0_101_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4340_ _4148_ VGND VGND VPWR VPWR _4149_ sky130_fd_sc_hd__buf_2
XFILLER_0_10_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6010_ _1574_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7961_ _3346_ _3611_ VGND VGND VPWR VPWR _3614_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7892_ _3536_ _3539_ VGND VGND VPWR VPWR _3545_ sky130_fd_sc_hd__or2b_1
X_6912_ _2565_ _2558_ _2567_ _2568_ VGND VGND VPWR VPWR _2569_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_76_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6843_ _2494_ _2489_ VGND VGND VPWR VPWR _2500_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6774_ _0388_ _2409_ _2410_ _2416_ VGND VGND VPWR VPWR _2431_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_43_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8513_ _3996_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__inv_2
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5725_ _1373_ _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__or2_1
XFILLER_0_94_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8444_ imem.address\[3\] imem.address\[2\] VGND VGND VPWR VPWR _4032_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_79_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5656_ _1312_ _1306_ _1212_ _1313_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__o211a_1
X_4607_ _4286_ _4288_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__nand2_1
X_8375_ _3996_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__inv_2
X_5587_ _0628_ _1229_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__or2_1
X_4538_ rf.registers\[25\]\[5\] _4164_ _4172_ rf.registers\[10\]\[5\] VGND VGND VPWR
+ VPWR _0235_ sky130_fd_sc_hd__a22o_1
X_7326_ _2958_ _2963_ VGND VGND VPWR VPWR _2983_ sky130_fd_sc_hd__xnor2_1
X_7257_ net66 _2403_ VGND VGND VPWR VPWR _2914_ sky130_fd_sc_hd__nand2_1
X_4469_ rf.registers\[25\]\[21\] _4166_ _4175_ rf.registers\[10\]\[21\] VGND VGND
+ VPWR VPWR _4278_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6208_ _1731_ _1866_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7188_ _2804_ _2844_ _2816_ VGND VGND VPWR VPWR _2845_ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6139_ _1578_ _1797_ _1694_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer9 _2250_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_51_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5510_ _0556_ _0619_ _1168_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__o21a_1
X_6490_ _2045_ _2090_ _2095_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__or3_1
XFILLER_0_42_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5441_ _1011_ _1017_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__nand2_1
X_8160_ _3812_ _3764_ _3776_ _3763_ VGND VGND VPWR VPWR _3813_ sky130_fd_sc_hd__a31o_1
X_5372_ _1011_ _1024_ _1030_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__a21oi_4
X_8091_ _2340_ _2354_ _3743_ _2366_ VGND VGND VPWR VPWR _3744_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_74_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7111_ _2720_ _2717_ VGND VGND VPWR VPWR _2768_ sky130_fd_sc_hd__or2b_1
X_7042_ _0954_ _2390_ VGND VGND VPWR VPWR _2699_ sky130_fd_sc_hd__nor2_1
X_7944_ _3588_ _3590_ _3584_ VGND VGND VPWR VPWR _3597_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_85_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7875_ _3363_ _3527_ VGND VGND VPWR VPWR _3528_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6826_ _2460_ _2471_ _2478_ _2481_ _2482_ VGND VGND VPWR VPWR _2483_ sky130_fd_sc_hd__o41a_2
X_6757_ _0480_ _2397_ VGND VGND VPWR VPWR _2414_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5708_ _1335_ _1364_ _1365_ _1366_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__a31o_1
X_6688_ _2262_ _2343_ _2344_ _2124_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_45_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5639_ _1189_ _1297_ _1221_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__mux2_2
X_8427_ _4023_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8358_ display.refresh_counter\[15\] _3986_ VGND VGND VPWR VPWR _3988_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_96_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7309_ _2393_ _2916_ _2935_ _2939_ VGND VGND VPWR VPWR _2966_ sky130_fd_sc_hd__a31o_1
Xhold150 rf.registers\[15\]\[19\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
Xhold161 rf.registers\[25\]\[24\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
X_8289_ _2396_ _3659_ VGND VGND VPWR VPWR _3942_ sky130_fd_sc_hd__or2_1
Xhold183 net10 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
Xhold172 rf.registers\[15\]\[12\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 display.refresh_counter\[4\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_16_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5990_ _1462_ _1635_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__nand2_1
X_4941_ net252 _4160_ _0390_ _0607_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__a31o_1
X_7660_ _0591_ _3314_ VGND VGND VPWR VPWR _3315_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4872_ _0550_ _0551_ _0552_ _0553_ _0554_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__a32o_1
XFILLER_0_59_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6611_ _2268_ VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7591_ _3234_ _3239_ _3236_ VGND VGND VPWR VPWR _3246_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6542_ _2196_ _2200_ _0639_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6473_ _2131_ _2053_ _2052_ VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__o21a_1
XFILLER_0_15_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8212_ _3721_ _3864_ net92 VGND VGND VPWR VPWR _3865_ sky130_fd_sc_hd__mux2_2
X_5424_ _1072_ _1077_ _1081_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__or4_4
X_8143_ _3791_ _3793_ _3795_ VGND VGND VPWR VPWR _3796_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_2_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5355_ _0915_ _0922_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8074_ _2230_ _3721_ VGND VGND VPWR VPWR _3727_ sky130_fd_sc_hd__nand2_1
X_5286_ _0943_ _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__nor2_1
X_7025_ _2675_ _2677_ _2678_ _2679_ _2681_ VGND VGND VPWR VPWR _2682_ sky130_fd_sc_hd__a2111oi_1
XFILLER_0_65_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7927_ _3568_ _3578_ _3579_ _3576_ VGND VGND VPWR VPWR _3580_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_77_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7858_ _3372_ _3506_ _3503_ _3510_ VGND VGND VPWR VPWR _3511_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_77_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6809_ _2465_ _2447_ VGND VGND VPWR VPWR _2466_ sky130_fd_sc_hd__or2b_1
X_7789_ _3383_ _3437_ VGND VGND VPWR VPWR _3442_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_71_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5140_ _0626_ _0746_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__nand2_1
X_5071_ _0691_ _0725_ _0720_ _0729_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__o31a_1
X_8830_ clknet_4_8_0_clk _0204_ VGND VGND VPWR VPWR rf.registers\[5\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_8761_ clknet_4_12_0_clk _0135_ _0034_ VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfrtp_1
X_5973_ _1617_ _1622_ _1626_ _1631_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__and4_1
XFILLER_0_87_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4924_ _0591_ _4156_ _0594_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_82_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7712_ _3118_ _2779_ _3364_ _1033_ VGND VGND VPWR VPWR _3365_ sky130_fd_sc_hd__a211o_1
X_8692_ clknet_4_14_0_clk _0066_ VGND VGND VPWR VPWR rf.registers\[25\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7643_ net39 _3296_ VGND VGND VPWR VPWR _3298_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4855_ _4150_ _0485_ _0476_ _0358_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__a31o_1
XFILLER_0_74_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7574_ _0556_ _3227_ _3228_ _3221_ VGND VGND VPWR VPWR _3229_ sky130_fd_sc_hd__o211a_1
X_4786_ _0469_ _0472_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__a21o_1
X_6525_ _2183_ _2089_ _2094_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__or3_1
XFILLER_0_30_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6456_ _1795_ _2114_ VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6387_ _0630_ _2045_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5407_ _0968_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__inv_2
X_8126_ _3774_ _3775_ _3778_ _3741_ _3736_ VGND VGND VPWR VPWR _3779_ sky130_fd_sc_hd__a311oi_2
XFILLER_0_100_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5338_ _0941_ _0902_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__nand2_1
X_8057_ net9 _2300_ VGND VGND VPWR VPWR _3710_ sky130_fd_sc_hd__nor2_1
X_7008_ _2608_ _2624_ _2637_ _2607_ VGND VGND VPWR VPWR _2665_ sky130_fd_sc_hd__a22o_1
X_5269_ _0926_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_54_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4640_ rf.registers\[25\]\[13\] _4167_ _4177_ rf.registers\[10\]\[13\] VGND VGND
+ VPWR VPWR _0337_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4571_ _0236_ _0267_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__nand2_1
X_6310_ _1887_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__inv_2
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7290_ _2393_ _2946_ VGND VGND VPWR VPWR _2947_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6241_ _1895_ _1898_ _1618_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__a21oi_1
X_6172_ _1800_ _1810_ _1828_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__o21ai_1
X_5123_ _0730_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__and2b_1
X_5054_ _0711_ _0706_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_68_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8813_ clknet_4_7_0_clk _0187_ VGND VGND VPWR VPWR rf.registers\[10\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8744_ clknet_4_0_0_clk _0118_ VGND VGND VPWR VPWR rf.registers\[15\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_5956_ _1611_ _1614_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4907_ _0226_ _0275_ _0276_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__or3_1
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8675_ net156 _4130_ VGND VGND VPWR VPWR _4139_ sky130_fd_sc_hd__and2_1
X_5887_ _1532_ _1527_ _1539_ _1545_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__a211o_1
X_7626_ net67 _3280_ VGND VGND VPWR VPWR _3281_ sky130_fd_sc_hd__nor2_1
X_4838_ _4158_ _0523_ _0525_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_31_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4769_ _0376_ _0403_ _4182_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__and3b_1
X_7557_ _3205_ _3207_ _3211_ VGND VGND VPWR VPWR _3212_ sky130_fd_sc_hd__o21a_1
X_6508_ _0647_ _2166_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__nand2_1
X_7488_ _3132_ _3135_ _3137_ _3131_ VGND VGND VPWR VPWR _3143_ sky130_fd_sc_hd__a22o_1
X_6439_ _1968_ _2097_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__nand2_1
X_8109_ _3660_ _3760_ _3761_ VGND VGND VPWR VPWR _3762_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_11_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold65 display.refresh_counter\[1\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 _0012_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_612 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold76 rf.registers\[10\]\[1\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 rf.registers\[10\]\[7\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 rf.registers\[5\]\[31\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer19 _3704_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_65_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6790_ _0505_ _2397_ VGND VGND VPWR VPWR _2447_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5810_ _1468_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__inv_2
XFILLER_0_8_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5741_ _1397_ _1398_ _1399_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__or3_4
X_8460_ _4041_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7411_ _3066_ _3067_ VGND VGND VPWR VPWR _3068_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5672_ _1326_ _1328_ _1330_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__o21bai_4
X_8391_ _4004_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4623_ _4256_ _0319_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__nand2_1
X_4554_ _0248_ _0250_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__and2_1
X_7342_ _2951_ _2965_ _2997_ _2998_ VGND VGND VPWR VPWR _2999_ sky130_fd_sc_hd__o211a_1
XFILLER_0_12_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7273_ _2921_ _2926_ _2929_ VGND VGND VPWR VPWR _2930_ sky130_fd_sc_hd__or3_1
XFILLER_0_12_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4485_ _4216_ _4293_ VGND VGND VPWR VPWR _4294_ sky130_fd_sc_hd__or2_1
X_6224_ _1784_ _1785_ _1787_ _1788_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_40_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6155_ _1766_ _1801_ _1803_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__or3_1
X_6086_ _1621_ _1744_ _1694_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__mux2_1
X_5106_ _0701_ _0713_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__xor2_1
X_5037_ _0694_ net91 _0655_ _0695_ net26 VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__o2111a_1
XTAP_TAPCELL_ROW_0_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8727_ clknet_4_8_0_clk _0101_ VGND VGND VPWR VPWR rf.registers\[15\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_6988_ _2596_ _2598_ _2599_ VGND VGND VPWR VPWR _2645_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_63_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5939_ _1491_ _1498_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8658_ _4107_ VGND VGND VPWR VPWR _4130_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_105_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8589_ _4093_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
X_7609_ _3258_ _3263_ VGND VGND VPWR VPWR _3264_ sky130_fd_sc_hd__and2_1
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_16_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput9 net9 VGND VGND VPWR VPWR an[7] sky130_fd_sc_hd__clkbuf_4
Xoutput11 net11 VGND VGND VPWR VPWR result[10] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput33 net33 VGND VGND VPWR VPWR result[30] sky130_fd_sc_hd__buf_2
Xoutput22 net22 VGND VGND VPWR VPWR result[20] sky130_fd_sc_hd__buf_2
Xoutput44 net44 VGND VGND VPWR VPWR seg[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7960_ _3346_ _3605_ _3607_ _3612_ VGND VGND VPWR VPWR _3613_ sky130_fd_sc_hd__o31a_1
XFILLER_0_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7891_ _3527_ _3538_ _3533_ VGND VGND VPWR VPWR _3544_ sky130_fd_sc_hd__a21o_1
X_6911_ _2405_ _2524_ _2404_ _2519_ VGND VGND VPWR VPWR _2568_ sky130_fd_sc_hd__a31o_1
XFILLER_0_76_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6842_ _2498_ _2480_ _2489_ _2479_ VGND VGND VPWR VPWR _2499_ sky130_fd_sc_hd__a31o_1
XFILLER_0_49_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6773_ _2415_ _2412_ VGND VGND VPWR VPWR _2430_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8512_ _4068_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5724_ _1264_ _1257_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_79_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5655_ _1312_ _1306_ _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8443_ _4031_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
X_8374_ _3996_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__inv_2
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4606_ _4290_ _4291_ _0302_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7325_ _2957_ VGND VGND VPWR VPWR _2982_ sky130_fd_sc_hd__inv_2
XFILLER_0_4_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5586_ _1120_ _1240_ _1241_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__a31oi_2
X_4537_ _4191_ _0231_ _0232_ _0233_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7256_ _0573_ _2912_ VGND VGND VPWR VPWR _2913_ sky130_fd_sc_hd__xnor2_1
X_4468_ _4228_ _4276_ VGND VGND VPWR VPWR _4277_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6207_ _0637_ _1724_ _1837_ _1818_ _1726_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__a221o_1
X_7187_ _2391_ _2804_ _2842_ _2843_ VGND VGND VPWR VPWR _2844_ sky130_fd_sc_hd__a31o_1
X_4399_ _4205_ _4206_ _4207_ VGND VGND VPWR VPWR _4208_ sky130_fd_sc_hd__nor3_2
X_6138_ _1677_ _1796_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__xor2_1
XFILLER_0_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6069_ _1609_ _1727_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5440_ _1096_ _1098_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_27_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5371_ _1028_ _1021_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__or3b_2
X_8090_ _2312_ _2361_ _2364_ VGND VGND VPWR VPWR _3743_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_74_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7110_ _2743_ _2746_ _2765_ _2766_ VGND VGND VPWR VPWR _2767_ sky130_fd_sc_hd__a211o_1
XFILLER_0_50_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7041_ _2693_ _2664_ _2697_ VGND VGND VPWR VPWR _2698_ sky130_fd_sc_hd__a21o_2
XFILLER_0_38_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_66_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7943_ _0591_ _3595_ net2 VGND VGND VPWR VPWR _3596_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7874_ _3525_ _3526_ VGND VGND VPWR VPWR _3527_ sky130_fd_sc_hd__and2_1
X_6825_ _2387_ _2470_ VGND VGND VPWR VPWR _2482_ sky130_fd_sc_hd__or2_1
XFILLER_0_37_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6756_ _2386_ _2406_ _0468_ VGND VGND VPWR VPWR _2413_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_75_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5707_ _1278_ _1335_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6687_ _2227_ _2262_ VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5638_ _1197_ _1296_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8426_ rf.registers\[25\]\[23\] _0521_ _4019_ VGND VGND VPWR VPWR _4023_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5569_ _1223_ _1227_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__xor2_1
X_8357_ _3986_ net117 VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold162 rf.registers\[10\]\[2\] VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_96_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold140 rf.registers\[10\]\[5\] VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
X_7308_ _2955_ _2964_ VGND VGND VPWR VPWR _2965_ sky130_fd_sc_hd__nand2_2
Xhold151 rf.registers\[15\]\[18\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
X_8288_ net35 _3659_ VGND VGND VPWR VPWR _3941_ sky130_fd_sc_hd__or2_1
Xhold173 rf.registers\[10\]\[10\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 rf.registers\[25\]\[13\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
X_7239_ _2892_ _2872_ VGND VGND VPWR VPWR _2896_ sky130_fd_sc_hd__or2b_1
XFILLER_0_95_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_84_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4940_ _0501_ _0583_ _0606_ _0550_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__a22o_1
X_4871_ _4200_ _0496_ _0500_ _0518_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__o22a_1
XFILLER_0_47_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6610_ _2196_ _2200_ VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7590_ _3243_ _3239_ _3244_ VGND VGND VPWR VPWR _3245_ sky130_fd_sc_hd__a21oi_1
X_6541_ net82 _2101_ _2199_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6472_ _2026_ _2029_ _2050_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_54_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8211_ _3862_ _3863_ VGND VGND VPWR VPWR _3864_ sky130_fd_sc_hd__or2_1
X_5423_ _1078_ _1080_ _0634_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__o21a_1
XFILLER_0_100_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8142_ _3321_ _3323_ _3794_ VGND VGND VPWR VPWR _3795_ sky130_fd_sc_hd__a21oi_1
X_5354_ _0915_ _0922_ net75 VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__o21a_1
XFILLER_0_23_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8073_ _3725_ _3722_ _3719_ VGND VGND VPWR VPWR _3726_ sky130_fd_sc_hd__nor3_2
X_5285_ _0857_ _0872_ _0800_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__and3b_1
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7024_ _2680_ _2668_ VGND VGND VPWR VPWR _2681_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7926_ _3573_ VGND VGND VPWR VPWR _3579_ sky130_fd_sc_hd__inv_2
X_7857_ _3372_ _3507_ _3503_ VGND VGND VPWR VPWR _3510_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_77_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6808_ _2433_ _2446_ _2448_ VGND VGND VPWR VPWR _2465_ sky130_fd_sc_hd__o21ai_1
X_7788_ _3435_ _3440_ _3436_ VGND VGND VPWR VPWR _3441_ sky130_fd_sc_hd__a21o_1
X_6739_ _2395_ VGND VGND VPWR VPWR _2396_ sky130_fd_sc_hd__buf_4
XFILLER_0_33_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8409_ rf.registers\[25\]\[15\] _0564_ _4008_ VGND VGND VPWR VPWR _4014_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_103_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5070_ _0728_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__inv_2
XFILLER_0_36_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8760_ clknet_4_13_0_clk _0134_ _0033_ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfrtp_4
X_5972_ _0629_ _1630_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__xnor2_1
X_4923_ _0592_ _0593_ net57 _0444_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_82_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7711_ _3338_ _3240_ net2 VGND VGND VPWR VPWR _3364_ sky130_fd_sc_hd__o21ai_1
X_8691_ clknet_4_14_0_clk _0065_ VGND VGND VPWR VPWR rf.registers\[25\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7642_ net39 _3296_ VGND VGND VPWR VPWR _3297_ sky130_fd_sc_hd__or2_1
X_4854_ _0534_ _0527_ _0539_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7573_ _0556_ _3227_ net64 VGND VGND VPWR VPWR _3228_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4785_ _4154_ _0473_ _0474_ _0477_ _4193_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__a32o_1
X_6524_ _1990_ _1993_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6455_ _2110_ _2111_ _2112_ _2113_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__o31a_1
XFILLER_0_30_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6386_ _1915_ _2044_ _1961_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5406_ _1055_ _1060_ _1061_ _1064_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__o211a_1
XFILLER_0_30_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8125_ _3748_ _3753_ _3777_ VGND VGND VPWR VPWR _3778_ sky130_fd_sc_hd__or3b_4
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5337_ _0900_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__inv_2
X_8056_ _2287_ VGND VGND VPWR VPWR _3709_ sky130_fd_sc_hd__buf_4
X_5268_ _0660_ _0908_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__nor2_1
X_7007_ _2663_ VGND VGND VPWR VPWR _2664_ sky130_fd_sc_hd__inv_2
X_5199_ _0633_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7909_ _3552_ _3559_ VGND VGND VPWR VPWR _3562_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4570_ _0235_ _0234_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__or2b_1
XFILLER_0_24_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6240_ _1618_ _1895_ _1898_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__and3_1
X_6171_ _1825_ _1829_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__nor2_1
X_5122_ _0729_ _0691_ _0720_ _0725_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__or4_1
XFILLER_0_41_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5053_ _0656_ _0705_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8812_ clknet_4_6_0_clk _0186_ VGND VGND VPWR VPWR rf.registers\[10\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5955_ _1613_ _1529_ _1528_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__o21a_1
X_8743_ clknet_4_2_0_clk _0117_ VGND VGND VPWR VPWR rf.registers\[15\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4906_ net67 _4156_ _0580_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__a21o_1
X_8674_ _4138_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
X_5886_ _1543_ _1544_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__or2_1
XFILLER_0_90_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7625_ _3279_ _3275_ _3277_ VGND VGND VPWR VPWR _3280_ sky130_fd_sc_hd__o21a_1
X_4837_ _4200_ _0416_ _0518_ _0398_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__o221a_1
XFILLER_0_90_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4768_ _0400_ _0402_ _0367_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7556_ net19 _3208_ _3204_ VGND VGND VPWR VPWR _3211_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_43_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6507_ _2024_ _2165_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__xnor2_2
X_4699_ _4326_ _4324_ _0346_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7487_ _3130_ _3133_ _3141_ VGND VGND VPWR VPWR _3142_ sky130_fd_sc_hd__a21oi_1
X_6438_ _2090_ _2095_ _2096_ _2085_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__o211a_1
X_8108_ _2372_ _2377_ _2382_ _2353_ VGND VGND VPWR VPWR _3761_ sky130_fd_sc_hd__a211o_1
XFILLER_0_87_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6369_ _1865_ _2015_ _2024_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__a21oi_1
X_8039_ _2251_ VGND VGND VPWR VPWR _3692_ sky130_fd_sc_hd__inv_2
Xhold55 display.refresh_counter\[8\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold77 rf.registers\[5\]\[5\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 display.refresh_counter\[4\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 rf.registers\[5\]\[26\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 rf.registers\[5\]\[29\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_11_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5740_ _1385_ _1244_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7410_ _3041_ _3059_ _3040_ VGND VGND VPWR VPWR _3067_ sky130_fd_sc_hd__a21oi_1
X_5671_ _1292_ _1329_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__or2b_1
X_8390_ net234 _0590_ _3997_ VGND VGND VPWR VPWR _4004_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4622_ _4257_ _4259_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4553_ _4190_ _0249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__nand2_1
X_7341_ _2950_ _2967_ VGND VGND VPWR VPWR _2998_ sky130_fd_sc_hd__or2_1
X_4484_ _4163_ _4213_ VGND VGND VPWR VPWR _4293_ sky130_fd_sc_hd__and2_1
X_7272_ _2913_ _2914_ _2928_ VGND VGND VPWR VPWR _2929_ sky130_fd_sc_hd__and3_1
XFILLER_0_52_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6223_ _1439_ _1881_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6154_ _1811_ _1812_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__nor2_1
X_5105_ _0741_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__nand2b_1
X_6085_ _1622_ _1743_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__xor2_1
X_5036_ net25 VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__inv_2
XFILLER_0_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6987_ _2633_ _2640_ _2642_ _2643_ VGND VGND VPWR VPWR _2644_ sky130_fd_sc_hd__a211o_2
XTAP_TAPCELL_ROW_36_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8726_ clknet_4_10_0_clk _0100_ VGND VGND VPWR VPWR rf.registers\[15\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_5938_ _1275_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_48_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8657_ _4129_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5869_ _0636_ _1521_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8588_ net196 _4083_ VGND VGND VPWR VPWR _4093_ sky130_fd_sc_hd__and2_1
X_7608_ _3250_ _3252_ _3255_ VGND VGND VPWR VPWR _3263_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_7_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7539_ _0534_ _3191_ VGND VGND VPWR VPWR _3194_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput12 net12 VGND VGND VPWR VPWR result[11] sky130_fd_sc_hd__buf_2
Xoutput23 net62 VGND VGND VPWR VPWR result[21] sky130_fd_sc_hd__buf_2
Xoutput34 net34 VGND VGND VPWR VPWR result[31] sky130_fd_sc_hd__buf_2
Xoutput45 net45 VGND VGND VPWR VPWR seg[3] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_8_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_565 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7890_ _3537_ _3540_ VGND VGND VPWR VPWR _3543_ sky130_fd_sc_hd__xnor2_1
X_6910_ net62 _2399_ _2566_ VGND VGND VPWR VPWR _2567_ sky130_fd_sc_hd__a21o_1
X_6841_ _2475_ _2477_ VGND VGND VPWR VPWR _2498_ sky130_fd_sc_hd__or2b_1
XFILLER_0_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8511_ net220 _4033_ VGND VGND VPWR VPWR _4068_ sky130_fd_sc_hd__and2_1
X_6772_ _2386_ _2417_ VGND VGND VPWR VPWR _2429_ sky130_fd_sc_hd__or2_2
XFILLER_0_45_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5723_ _1331_ net54 _1332_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_84_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5654_ _1207_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__inv_2
X_8442_ net221 _0387_ _4241_ VGND VGND VPWR VPWR _4031_ sky130_fd_sc_hd__mux2_1
X_8373_ _3996_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__inv_2
X_4605_ _4297_ _0300_ _0301_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__o21a_1
XFILLER_0_103_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7324_ _2965_ _2979_ _2968_ _2980_ VGND VGND VPWR VPWR _2981_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_13_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5585_ _1232_ _1243_ _1231_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__mux2_2
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4536_ _0231_ _0232_ _4191_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__a21oi_1
X_7255_ _2393_ _2911_ VGND VGND VPWR VPWR _2912_ sky130_fd_sc_hd__nor2_1
X_4467_ _4229_ _4261_ VGND VGND VPWR VPWR _4276_ sky130_fd_sc_hd__nor2_1
X_4398_ rf.registers\[5\]\[10\] _4147_ _4172_ rf.registers\[15\]\[10\] VGND VGND VPWR
+ VPWR _4207_ sky130_fd_sc_hd__a22o_1
X_6206_ _1766_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__buf_6
X_7186_ _2805_ _2812_ VGND VGND VPWR VPWR _2843_ sky130_fd_sc_hd__and2_1
X_6137_ _1664_ _1667_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__nor2_1
X_6068_ _0637_ _1607_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__nor2_1
X_5019_ net33 _0677_ net31 VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_310 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8709_ clknet_4_3_0_clk _0083_ VGND VGND VPWR VPWR rf.registers\[25\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_103_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5370_ _0660_ _0770_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_74_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7040_ _2693_ _2664_ _2666_ _2662_ VGND VGND VPWR VPWR _2697_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7942_ _3304_ _3594_ net3 VGND VGND VPWR VPWR _3595_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7873_ _3366_ _3524_ VGND VGND VPWR VPWR _3526_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6824_ _2479_ _2480_ VGND VGND VPWR VPWR _2481_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6755_ _0683_ net33 _0428_ _2397_ VGND VGND VPWR VPWR _2412_ sky130_fd_sc_hd__nand4_4
X_5706_ _1357_ _1363_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__nand2_1
X_6686_ _2341_ _2342_ VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8425_ _4022_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5637_ _0628_ _1182_ _1184_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5568_ _1143_ _1226_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__nor2_1
X_8356_ display.refresh_counter\[13\] _3984_ net116 VGND VGND VPWR VPWR _3987_ sky130_fd_sc_hd__a21oi_1
X_8287_ _3650_ _3932_ _3939_ VGND VGND VPWR VPWR _3940_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_96_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold152 rf.registers\[25\]\[2\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
X_4519_ _4206_ _4327_ VGND VGND VPWR VPWR _4328_ sky130_fd_sc_hd__xor2_1
X_7307_ _2958_ _2963_ _2917_ _2957_ VGND VGND VPWR VPWR _2964_ sky130_fd_sc_hd__a2bb2o_1
Xhold130 rf.registers\[15\]\[21\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
Xhold141 rf.registers\[5\]\[27\] VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
Xhold185 net21 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
Xhold163 rf.registers\[25\]\[0\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
Xhold174 rf.registers\[25\]\[11\] VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
X_7238_ _2893_ _2894_ _2891_ VGND VGND VPWR VPWR _2895_ sky130_fd_sc_hd__a21oi_1
X_5499_ _0628_ _1151_ _1157_ _0971_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__o2bb2a_1
X_7169_ _2821_ _2825_ VGND VGND VPWR VPWR _2826_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_16_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4870_ _4150_ _0485_ _0501_ _0358_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__a31o_1
XFILLER_0_24_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6540_ _2197_ _2198_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6471_ _2089_ _2094_ _2039_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__or3b_1
X_8210_ _3858_ _3855_ _3722_ _3861_ VGND VGND VPWR VPWR _3863_ sky130_fd_sc_hd__a211oi_1
X_5422_ _0634_ _1078_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__nor3_1
XFILLER_0_2_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8141_ _3321_ _3325_ _3323_ VGND VGND VPWR VPWR _3794_ sky130_fd_sc_hd__a21oi_1
X_5353_ _0800_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__buf_6
XFILLER_0_100_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8072_ _2290_ _3724_ _2384_ VGND VGND VPWR VPWR _3725_ sky130_fd_sc_hd__mux2_2
X_5284_ _0649_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__and2_4
XFILLER_0_49_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7023_ _2633_ _2640_ VGND VGND VPWR VPWR _2680_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7925_ _3571_ _3577_ VGND VGND VPWR VPWR _3578_ sky130_fd_sc_hd__or2b_1
XFILLER_0_77_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7856_ _3369_ _3508_ VGND VGND VPWR VPWR _3509_ sky130_fd_sc_hd__and2_1
X_6807_ _2443_ _2437_ _2463_ VGND VGND VPWR VPWR _2464_ sky130_fd_sc_hd__o21a_1
X_4999_ display.refresh_counter\[17\] VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__inv_2
XFILLER_0_18_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7787_ _3430_ _3434_ VGND VGND VPWR VPWR _3440_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_98_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6738_ _2394_ VGND VGND VPWR VPWR _2395_ sky130_fd_sc_hd__buf_2
XFILLER_0_18_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6669_ _2128_ _2314_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_21_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8408_ _4013_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
X_8339_ _3976_ _3977_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5971_ _1627_ _1629_ net70 VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__mux2_2
X_8690_ clknet_4_11_0_clk _0064_ VGND VGND VPWR VPWR rf.registers\[25\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_4922_ _0268_ _0242_ _0266_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__and3_1
X_7710_ _1492_ _3362_ net2 VGND VGND VPWR VPWR _3363_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_82_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7641_ _3293_ _3295_ VGND VGND VPWR VPWR _3296_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4853_ _0535_ _0536_ _0537_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_47_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4784_ _0475_ _0476_ _0445_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__mux2_1
X_7572_ _3222_ _3225_ _3217_ VGND VGND VPWR VPWR _3227_ sky130_fd_sc_hd__a21oi_2
X_6523_ _2177_ _2178_ _2181_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__nor3_1
XFILLER_0_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6454_ net87 _2095_ _1979_ VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__or3b_1
XFILLER_0_15_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5405_ _1032_ _1063_ _1054_ _0906_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_93_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6385_ _2041_ _2043_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8124_ _3776_ _3763_ _3764_ VGND VGND VPWR VPWR _3777_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5336_ _0896_ _0961_ _0993_ _0994_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__a22o_1
X_8055_ _3707_ _3675_ _3680_ _3704_ _3673_ VGND VGND VPWR VPWR _3708_ sky130_fd_sc_hd__o41a_1
X_5267_ _0924_ _0925_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7006_ _2389_ _2662_ VGND VGND VPWR VPWR _2663_ sky130_fd_sc_hd__nand2_1
X_5198_ _0791_ _0836_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__mux2_4
XFILLER_0_78_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7908_ _3548_ _3557_ _3558_ _3560_ VGND VGND VPWR VPWR _3561_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_54_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7839_ _3338_ _3219_ _2668_ _3118_ VGND VGND VPWR VPWR _3492_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload0 clknet_4_0_0_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinv_1
XFILLER_0_33_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6170_ _1800_ _1810_ _1828_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__nor3_1
X_5121_ _0626_ _0689_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__nand2_1
X_5052_ _0619_ _0707_ _0708_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8811_ clknet_4_6_0_clk _0185_ VGND VGND VPWR VPWR rf.registers\[10\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_8742_ clknet_4_2_0_clk _0116_ VGND VGND VPWR VPWR rf.registers\[15\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_5954_ _1612_ _1525_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__and2_1
X_4905_ _0469_ _0502_ _0579_ _4158_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a22o_1
X_8673_ net208 _4130_ VGND VGND VPWR VPWR _4138_ sky130_fd_sc_hd__and2_1
X_5885_ _1294_ _1542_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7624_ net67 _3278_ VGND VGND VPWR VPWR _3279_ sky130_fd_sc_hd__nor2_1
X_4836_ _4150_ _0485_ _0405_ _0357_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a31o_1
XFILLER_0_47_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7555_ net63 _3209_ VGND VGND VPWR VPWR _3210_ sky130_fd_sc_hd__or2_1
X_6506_ net87 _2095_ _2164_ _2159_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__o211a_1
X_4767_ _0459_ _0460_ _0369_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4698_ _0392_ _0393_ _0339_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7486_ _3133_ _3135_ _3130_ VGND VGND VPWR VPWR _3141_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6437_ _1980_ _2070_ _2076_ _2087_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__a211o_1
XFILLER_0_15_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6368_ _2016_ _2018_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__and2_1
X_8107_ _2356_ _3759_ VGND VGND VPWR VPWR _3760_ sky130_fd_sc_hd__xnor2_1
X_5319_ _0885_ _0891_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__nor2_1
X_6299_ _1813_ net51 VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__xor2_1
X_8038_ _3675_ _3680_ _3685_ _3690_ VGND VGND VPWR VPWR _3691_ sky130_fd_sc_hd__or4b_4
Xhold56 _3979_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 display.refresh_counter\[13\] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 rf.registers\[5\]\[28\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 rf.registers\[10\]\[20\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5670_ _1294_ _1222_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__or2_2
XFILLER_0_57_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4621_ _4266_ _0316_ _0317_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4552_ _4186_ _4189_ _4182_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__o21ai_1
X_7340_ _2951_ _2965_ VGND VGND VPWR VPWR _2997_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4483_ rf.registers\[25\]\[17\] _4165_ _4175_ rf.registers\[10\]\[17\] VGND VGND
+ VPWR VPWR _4292_ sky130_fd_sc_hd__a22oi_1
X_7271_ _2893_ _2927_ _2922_ VGND VGND VPWR VPWR _2928_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_77_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6222_ _1747_ _1750_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_90_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6153_ _1682_ _1723_ _1687_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5104_ _0740_ _0736_ _0715_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__a21o_1
X_6084_ _1617_ _1738_ _1742_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__a21oi_1
X_5035_ net24 VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6986_ _2634_ _2627_ _2641_ VGND VGND VPWR VPWR _2643_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_36_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8725_ clknet_4_10_0_clk _0099_ VGND VGND VPWR VPWR rf.registers\[15\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_5937_ _1486_ _1592_ _1591_ _1593_ _1595_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__o32a_4
XFILLER_0_75_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8656_ net149 _4119_ VGND VGND VPWR VPWR _4129_ sky130_fd_sc_hd__and2_1
X_7607_ _3261_ VGND VGND VPWR VPWR _3262_ sky130_fd_sc_hd__inv_2
X_5868_ _1502_ _1506_ _1526_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__o21bai_4
X_8587_ _4092_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
X_5799_ _1387_ _1391_ _1417_ _1393_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__a31oi_1
X_4819_ _0313_ _4273_ _0312_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__or3_1
XFILLER_0_105_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7538_ _3187_ _3188_ _3192_ _3186_ VGND VGND VPWR VPWR _3193_ sky130_fd_sc_hd__a22o_1
X_7469_ _0683_ _0428_ VGND VGND VPWR VPWR _3124_ sky130_fd_sc_hd__or2_1
Xoutput13 net13 VGND VGND VPWR VPWR result[12] sky130_fd_sc_hd__buf_2
XFILLER_0_3_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput24 net24 VGND VGND VPWR VPWR result[22] sky130_fd_sc_hd__buf_2
Xoutput35 net35 VGND VGND VPWR VPWR result[3] sky130_fd_sc_hd__clkbuf_4
Xoutput46 net46 VGND VGND VPWR VPWR seg[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6840_ _2387_ _2496_ VGND VGND VPWR VPWR _2497_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6771_ _2423_ net58 _2426_ _2427_ VGND VGND VPWR VPWR _2428_ sky130_fd_sc_hd__o211a_2
X_8510_ _4067_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
X_5722_ _1249_ _1286_ _1324_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8441_ _4030_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
X_5653_ _1209_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__inv_2
X_8372_ _3996_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__inv_2
XFILLER_0_72_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4604_ _4290_ _4291_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__xor2_1
X_5584_ _1226_ _1242_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4535_ _4163_ _4190_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__nand2_1
X_7323_ _2954_ VGND VGND VPWR VPWR _2980_ sky130_fd_sc_hd__inv_2
X_7254_ _2887_ _2908_ _2910_ VGND VGND VPWR VPWR _2911_ sky130_fd_sc_hd__o21a_2
XFILLER_0_40_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4466_ rf.registers\[25\]\[22\] _4166_ _4175_ rf.registers\[10\]\[22\] VGND VGND
+ VPWR VPWR _4275_ sky130_fd_sc_hd__a22oi_4
X_4397_ rf.registers\[5\]\[9\] _4147_ _4172_ rf.registers\[15\]\[9\] VGND VGND VPWR
+ VPWR _4206_ sky130_fd_sc_hd__a22o_1
X_6205_ _0630_ _1863_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__xnor2_1
X_7185_ _2840_ _2841_ VGND VGND VPWR VPWR _2842_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6136_ _1005_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__clkbuf_4
X_6067_ _1703_ _1718_ _1719_ _1720_ _1725_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__a221oi_4
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5018_ _0642_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__inv_4
XFILLER_0_95_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6969_ _2588_ _2603_ _2625_ VGND VGND VPWR VPWR _2626_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_63_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8708_ clknet_4_3_0_clk _0082_ VGND VGND VPWR VPWR rf.registers\[25\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8639_ _4120_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7941_ _1964_ _3031_ _3119_ VGND VGND VPWR VPWR _3594_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7872_ _3366_ _3524_ VGND VGND VPWR VPWR _3525_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_85_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6823_ _2464_ _2474_ VGND VGND VPWR VPWR _2480_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6754_ _0683_ _2386_ _2409_ VGND VGND VPWR VPWR _2411_ sky130_fd_sc_hd__or3b_2
XFILLER_0_45_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6685_ _2336_ _2337_ _2142_ VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__o21a_1
XFILLER_0_70_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5705_ _1357_ _1363_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__or2_1
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5636_ _1294_ _1222_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8424_ rf.registers\[25\]\[22\] _0526_ _4019_ VGND VGND VPWR VPWR _4022_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5567_ _1224_ _1225_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__and2_1
X_8355_ net260 display.refresh_counter\[14\] _3984_ VGND VGND VPWR VPWR _3986_ sky130_fd_sc_hd__and3_1
XFILLER_0_41_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8286_ _3659_ _3650_ _3641_ VGND VGND VPWR VPWR _3939_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_96_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold142 rf.registers\[15\]\[4\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
X_4518_ _4163_ _4205_ VGND VGND VPWR VPWR _4327_ sky130_fd_sc_hd__nand2_1
X_7306_ _2960_ _2961_ _2962_ VGND VGND VPWR VPWR _2963_ sky130_fd_sc_hd__or3b_1
Xhold131 rf.registers\[10\]\[18\] VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
Xhold153 rf.registers\[15\]\[31\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
X_5498_ _0627_ _1151_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__o21bai_1
Xhold120 rf.registers\[25\]\[20\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd3_1
Xhold175 imem.address\[3\] VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xhold164 rf.registers\[25\]\[9\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
X_7237_ net12 _2392_ VGND VGND VPWR VPWR _2894_ sky130_fd_sc_hd__nor2_1
X_4449_ _4179_ _4233_ _4235_ VGND VGND VPWR VPWR _4258_ sky130_fd_sc_hd__and3_1
Xhold186 rf.registers\[25\]\[25\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
X_7168_ _2822_ _2816_ _2821_ _2823_ _2824_ VGND VGND VPWR VPWR _2825_ sky130_fd_sc_hd__a311o_1
X_6119_ _1761_ _1777_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__xnor2_1
X_7099_ _2750_ _2755_ VGND VGND VPWR VPWR _2756_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_16_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6470_ _2115_ _2118_ _2123_ _2128_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_70_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5421_ _1068_ _1079_ _1053_ _1052_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__o211a_1
X_8140_ _3320_ _3792_ VGND VGND VPWR VPWR _3793_ sky130_fd_sc_hd__xnor2_1
X_5352_ _1008_ _0992_ _1000_ _1010_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__o31a_4
XFILLER_0_2_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8071_ net73 _3723_ VGND VGND VPWR VPWR _3724_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5283_ _0857_ _0905_ _0941_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__mux2_4
X_7022_ _2401_ _2668_ _0876_ VGND VGND VPWR VPWR _2679_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7924_ _3572_ _3573_ _3576_ VGND VGND VPWR VPWR _3577_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_65_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7855_ _3372_ _3507_ VGND VGND VPWR VPWR _3508_ sky130_fd_sc_hd__xor2_1
XFILLER_0_81_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6806_ _2437_ _2444_ VGND VGND VPWR VPWR _2463_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4998_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__buf_4
X_7786_ _3431_ _3434_ _3438_ VGND VGND VPWR VPWR _3439_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_98_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6737_ _2393_ VGND VGND VPWR VPWR _2394_ sky130_fd_sc_hd__buf_2
X_6668_ _1052_ _2324_ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_21_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6599_ _2157_ _2219_ _2232_ VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__a21oi_1
X_8407_ net258 _0566_ _4008_ VGND VGND VPWR VPWR _4013_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5619_ _1240_ _1241_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8338_ net128 _3974_ VGND VGND VPWR VPWR _3977_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8269_ _2276_ _3873_ _3874_ _3877_ _3875_ VGND VGND VPWR VPWR _3922_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_57_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5970_ _1613_ _1628_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__or2_1
X_4921_ _0550_ _0269_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7640_ _3283_ _3294_ _3286_ VGND VGND VPWR VPWR _3295_ sky130_fd_sc_hd__mux2_1
X_4852_ _4150_ _0485_ _0464_ _0357_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4783_ _0383_ _0354_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7571_ _3217_ _3223_ _3225_ VGND VGND VPWR VPWR _3226_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6522_ _2180_ _2171_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__or2b_1
XFILLER_0_27_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6453_ _2069_ _2066_ _2067_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5404_ _1062_ _0955_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__xor2_1
X_8123_ _1856_ _3756_ VGND VGND VPWR VPWR _3776_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6384_ _1916_ _2042_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5335_ _0893_ _0897_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__or2_1
X_8054_ _3705_ _3706_ VGND VGND VPWR VPWR _3707_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5266_ _0908_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__inv_2
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7005_ _2612_ _2627_ _2661_ VGND VGND VPWR VPWR _2662_ sky130_fd_sc_hd__o21a_1
X_5197_ _0855_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__buf_6
XFILLER_0_97_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7907_ _3559_ VGND VGND VPWR VPWR _3560_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_54_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7838_ _3341_ _0789_ VGND VGND VPWR VPWR _3491_ sky130_fd_sc_hd__or2_1
X_7769_ _3414_ _3421_ VGND VGND VPWR VPWR _3422_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload1 clknet_4_1_0_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_61_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5120_ _0739_ _0769_ _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__a21o_1
X_5051_ _0709_ _0623_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__nand2_1
X_8810_ clknet_4_4_0_clk _0184_ VGND VGND VPWR VPWR rf.registers\[10\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8741_ clknet_4_2_0_clk _0115_ VGND VGND VPWR VPWR rf.registers\[15\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5953_ _1502_ _1506_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__or2_1
X_4904_ _0280_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8672_ _4137_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
X_5884_ _1294_ _1542_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7623_ _1838_ _3273_ VGND VGND VPWR VPWR _3278_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4835_ _0310_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__nor2_1
X_4766_ _0396_ _0399_ _0367_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7554_ net19 _3208_ VGND VGND VPWR VPWR _3209_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6505_ _2013_ _2160_ _2163_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__nand3b_1
XTAP_TAPCELL_ROW_31_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4697_ _4319_ _4316_ _0346_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7485_ _0480_ _3139_ VGND VGND VPWR VPWR _3140_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6436_ _2094_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__buf_4
XFILLER_0_70_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6367_ _1988_ _2025_ _2014_ _2004_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__or4_4
XFILLER_0_30_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8106_ _2312_ _2361_ _2359_ VGND VGND VPWR VPWR _3759_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5318_ _0880_ _0881_ _0879_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__o21ai_1
X_6298_ _1832_ _1956_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__nor2_1
X_8037_ net6 _3684_ _3689_ VGND VGND VPWR VPWR _3690_ sky130_fd_sc_hd__a21o_1
X_5249_ net88 _0854_ _0686_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__o21a_1
Xhold57 display.refresh_counter\[11\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 display.refresh_counter\[7\] VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 rf.registers\[5\]\[25\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4620_ _4257_ _4259_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__xor2_1
XFILLER_0_25_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4551_ rf.registers\[25\]\[2\] _4164_ _4171_ rf.registers\[10\]\[2\] VGND VGND VPWR
+ VPWR _0248_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4482_ _4220_ _4221_ _4287_ VGND VGND VPWR VPWR _4291_ sky130_fd_sc_hd__a21o_1
X_7270_ _0573_ _2403_ _2911_ VGND VGND VPWR VPWR _2927_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_77_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6221_ _1876_ _1878_ _1873_ _1877_ _1879_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__o41a_1
XTAP_TAPCELL_ROW_90_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6152_ _1687_ _1682_ _1723_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5103_ _0667_ _0633_ _0747_ _0760_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__o221a_1
X_6083_ _1597_ _1616_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__nor2_1
X_5034_ _0668_ _0665_ _0666_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_0_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6985_ _2641_ _2634_ _2627_ VGND VGND VPWR VPWR _2642_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_36_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8724_ clknet_4_11_0_clk _0098_ VGND VGND VPWR VPWR rf.registers\[15\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_5936_ _1594_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__inv_2
X_8655_ _4128_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7606_ _0573_ _3260_ VGND VGND VPWR VPWR _3261_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5867_ _1513_ _1522_ _1518_ _1525_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__or4b_4
XFILLER_0_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8586_ net198 _4083_ VGND VGND VPWR VPWR _4092_ sky130_fd_sc_hd__and2_1
X_4818_ _0506_ _0507_ _0445_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__mux2_1
X_5798_ _1380_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__inv_2
XFILLER_0_105_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4749_ _0442_ _0443_ _0344_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7537_ _0534_ _3191_ VGND VGND VPWR VPWR _3192_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7468_ _3122_ VGND VGND VPWR VPWR _3123_ sky130_fd_sc_hd__inv_2
XFILLER_0_101_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6419_ _1957_ _1962_ _2077_ _1956_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__a22o_1
Xoutput25 net25 VGND VGND VPWR VPWR result[23] sky130_fd_sc_hd__buf_2
Xoutput14 net14 VGND VGND VPWR VPWR result[13] sky130_fd_sc_hd__buf_2
Xoutput36 net36 VGND VGND VPWR VPWR result[4] sky130_fd_sc_hd__clkbuf_4
Xoutput47 net47 VGND VGND VPWR VPWR seg[5] sky130_fd_sc_hd__buf_4
X_7399_ _3018_ _3055_ VGND VGND VPWR VPWR _3056_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_8_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6770_ _2419_ _2420_ VGND VGND VPWR VPWR _2427_ sky130_fd_sc_hd__nand2_1
X_5721_ _1274_ net100 _1378_ _1379_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__o2bb2a_4
XFILLER_0_72_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8440_ net222 _0427_ _4241_ VGND VGND VPWR VPWR _4030_ sky130_fd_sc_hd__mux2_1
X_5652_ _1212_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__inv_2
X_8371_ _3995_ VGND VGND VPWR VPWR _3996_ sky130_fd_sc_hd__buf_4
X_4603_ _4298_ _0299_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_13_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5583_ _1224_ _1225_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4534_ _4200_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__inv_2
X_7322_ _2955_ _2964_ _2967_ VGND VGND VPWR VPWR _2979_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_581 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7253_ _2858_ _2909_ _2883_ VGND VGND VPWR VPWR _2910_ sky130_fd_sc_hd__mux2_1
X_4465_ _4262_ _4272_ _4271_ VGND VGND VPWR VPWR _4274_ sky130_fd_sc_hd__and3_1
X_4396_ _4201_ _4202_ _4203_ _4204_ VGND VGND VPWR VPWR _4205_ sky130_fd_sc_hd__or4_2
X_6204_ _1702_ _1862_ _1821_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__mux2_2
X_7184_ net55 _2810_ VGND VGND VPWR VPWR _2841_ sky130_fd_sc_hd__nor2_1
X_6135_ _1783_ _1789_ _1793_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__a21oi_1
X_6066_ _0637_ _1724_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5017_ _0671_ _0672_ _0674_ _0675_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__a31o_1
X_8707_ clknet_4_7_0_clk _0081_ VGND VGND VPWR VPWR rf.registers\[25\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_6968_ _2587_ _2592_ _2589_ VGND VGND VPWR VPWR _2625_ sky130_fd_sc_hd__a21bo_1
X_6899_ _2533_ _2540_ _2552_ _2555_ VGND VGND VPWR VPWR _2556_ sky130_fd_sc_hd__a31o_1
X_5919_ _1538_ _1577_ _1570_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8638_ net160 _4119_ VGND VGND VPWR VPWR _4120_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8569_ _4071_ VGND VGND VPWR VPWR _4083_ sky130_fd_sc_hd__buf_2
XFILLER_0_63_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7940_ _3588_ _3592_ VGND VGND VPWR VPWR _3593_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7871_ _3521_ _3523_ VGND VGND VPWR VPWR _3524_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_85_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6822_ _2461_ _2468_ VGND VGND VPWR VPWR _2479_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_35_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6753_ net61 _0468_ _2409_ _0428_ VGND VGND VPWR VPWR _2410_ sky130_fd_sc_hd__o31a_1
X_6684_ _2137_ _2138_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__and2_1
XFILLER_0_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5704_ _1345_ _1358_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__nor2_1
X_5635_ _0924_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__buf_6
XFILLER_0_33_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8423_ _4021_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold110 rf.registers\[10\]\[14\] VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
X_5566_ _1158_ _1174_ _1179_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__a21oi_1
X_8354_ net134 _3984_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__xor2_1
X_8285_ _3933_ _3937_ _3648_ VGND VGND VPWR VPWR _3938_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_96_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4517_ rf.registers\[25\]\[9\] _4164_ _4173_ rf.registers\[10\]\[9\] VGND VGND VPWR
+ VPWR _4326_ sky130_fd_sc_hd__a22o_1
Xhold121 rf.registers\[5\]\[15\] VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
X_7305_ _2944_ _2948_ VGND VGND VPWR VPWR _2962_ sky130_fd_sc_hd__or2_1
Xhold132 rf.registers\[15\]\[17\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5497_ _1152_ _1155_ _1116_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__mux2_2
XFILLER_0_41_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_44_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold143 rf.registers\[15\]\[25\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold176 rf.registers\[25\]\[10\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
X_7236_ _1492_ net53 _2891_ _2892_ VGND VGND VPWR VPWR _2893_ sky130_fd_sc_hd__o22a_1
Xhold154 rf.registers\[25\]\[31\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
X_4448_ rf.registers\[25\]\[26\] _4166_ _4176_ rf.registers\[10\]\[26\] VGND VGND
+ VPWR VPWR _4257_ sky130_fd_sc_hd__a22o_1
Xhold165 rf.registers\[15\]\[22\] VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold187 rf.registers\[25\]\[27\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
X_4379_ rf.registers\[5\]\[0\] net265 _4170_ rf.registers\[15\]\[0\] _4181_ VGND VGND
+ VPWR VPWR _4188_ sky130_fd_sc_hd__a221oi_4
X_7167_ _1406_ _2402_ VGND VGND VPWR VPWR _2824_ sky130_fd_sc_hd__nand2_1
X_6118_ _1610_ _1760_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__nand2_1
X_7098_ _2751_ _2754_ VGND VGND VPWR VPWR _2755_ sky130_fd_sc_hd__or2_1
X_6049_ _0573_ _0620_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_53_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5420_ _0975_ _1067_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5351_ _1009_ _1007_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__nand2_4
XFILLER_0_2_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8070_ _2291_ _2281_ _2286_ VGND VGND VPWR VPWR _3723_ sky130_fd_sc_hd__and3_1
X_5282_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__buf_6
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7021_ _0876_ _2400_ _2668_ VGND VGND VPWR VPWR _2678_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7923_ _3563_ _3574_ _3575_ _3561_ VGND VGND VPWR VPWR _3576_ sky130_fd_sc_hd__o22a_1
XFILLER_0_77_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7854_ _3501_ _3504_ _3506_ VGND VGND VPWR VPWR _3507_ sky130_fd_sc_hd__o21a_1
XFILLER_0_65_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6805_ _2452_ _2461_ VGND VGND VPWR VPWR _2462_ sky130_fd_sc_hd__or2_1
X_7785_ _3383_ _3437_ _3429_ VGND VGND VPWR VPWR _3438_ sky130_fd_sc_hd__o21a_1
X_6736_ _2392_ VGND VGND VPWR VPWR _2393_ sky130_fd_sc_hd__buf_2
X_4997_ _0653_ _0655_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_98_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6667_ _2122_ _2323_ _2296_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6598_ _2109_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__inv_2
X_8406_ _4012_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5618_ _1120_ _1253_ _1256_ _1276_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__o31a_1
XFILLER_0_103_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5549_ _0650_ _1206_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__nor2_1
X_8337_ display.refresh_counter\[6\] _3974_ VGND VGND VPWR VPWR _3976_ sky130_fd_sc_hd__and2_1
X_8268_ _3875_ _3876_ _3878_ _3920_ VGND VGND VPWR VPWR _3921_ sky130_fd_sc_hd__and4bb_1
X_8199_ _3845_ _3846_ _3847_ _3851_ VGND VGND VPWR VPWR _3852_ sky130_fd_sc_hd__and4b_1
X_7219_ _2862_ _2869_ VGND VGND VPWR VPWR _2876_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_57_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4920_ net37 VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__buf_4
XFILLER_0_59_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4851_ _4200_ _0457_ _0461_ _0518_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__o22a_1
XFILLER_0_59_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4782_ _0343_ _0349_ _0344_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__mux2_1
X_7570_ _3216_ _3210_ _3224_ VGND VGND VPWR VPWR _3225_ sky130_fd_sc_hd__o21ai_2
X_6521_ _2027_ _2179_ _2102_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__mux2_2
XFILLER_0_70_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6452_ _2090_ _2095_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__nor2_2
XFILLER_0_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5403_ _0619_ _0951_ _0953_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__a21bo_1
X_8122_ _3709_ _3752_ VGND VGND VPWR VPWR _3775_ sky130_fd_sc_hd__or2_1
X_6383_ _0646_ _1915_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5334_ _0893_ _0897_ _0961_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__a21oi_1
X_8053_ _2302_ _3684_ VGND VGND VPWR VPWR _3706_ sky130_fd_sc_hd__xnor2_2
X_5265_ _0923_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__buf_4
X_5196_ _0854_ _0853_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__nor2_4
X_7004_ _2624_ _2637_ _2660_ VGND VGND VPWR VPWR _2661_ sky130_fd_sc_hd__or3_1
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7906_ _3556_ _3558_ _3548_ VGND VGND VPWR VPWR _3559_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_54_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7837_ _3374_ _3489_ VGND VGND VPWR VPWR _3490_ sky130_fd_sc_hd__xnor2_1
X_7768_ _3415_ _3419_ _3417_ VGND VGND VPWR VPWR _3421_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6719_ _2106_ _2373_ VGND VGND VPWR VPWR _2376_ sky130_fd_sc_hd__xor2_2
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7699_ net40 _3342_ _3350_ _3351_ VGND VGND VPWR VPWR _3352_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload2 clknet_4_2_0_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_104_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5050_ net62 VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__inv_2
X_8740_ clknet_4_2_0_clk _0114_ VGND VGND VPWR VPWR rf.registers\[15\]\[20\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_9_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5952_ _1518_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__inv_2
XFILLER_0_87_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4903_ _0279_ _4333_ _0277_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__and3_1
XFILLER_0_62_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5883_ _1540_ _1541_ _1533_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__mux2_1
X_8671_ net155 _4130_ VGND VGND VPWR VPWR _4137_ sky130_fd_sc_hd__and2_1
XFILLER_0_90_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7622_ _3272_ _3276_ VGND VGND VPWR VPWR _3277_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4834_ _0309_ _4281_ _0308_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__and3_1
XFILLER_0_90_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4765_ _0393_ _0395_ _0339_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7553_ _3203_ _3205_ _3207_ VGND VGND VPWR VPWR _3208_ sky130_fd_sc_hd__a21boi_2
X_6504_ _2161_ _2162_ _2019_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4696_ _0337_ _4306_ _0346_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__mux2_1
X_7484_ _3137_ _3138_ VGND VGND VPWR VPWR _3139_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6435_ _2093_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__inv_1
XFILLER_0_3_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6366_ _1865_ _2015_ _2019_ _2024_ _2020_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__a2111o_1
X_8105_ _3757_ VGND VGND VPWR VPWR _3758_ sky130_fd_sc_hd__inv_2
XFILLER_0_87_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5317_ _0960_ _0956_ _0969_ _0970_ _0975_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__o2111a_1
X_8036_ _2276_ _3688_ VGND VGND VPWR VPWR _3689_ sky130_fd_sc_hd__nor2_1
X_6297_ _1954_ _1955_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__or2_1
X_5248_ _0684_ net101 net81 VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__or3_1
X_5179_ _0783_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__xor2_1
Xhold58 _3983_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 display.refresh_counter\[10\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4550_ _0244_ _0246_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4481_ rf.registers\[25\]\[18\] _4166_ _4175_ rf.registers\[10\]\[18\] VGND VGND
+ VPWR VPWR _4290_ sky130_fd_sc_hd__a22o_1
XFILLER_0_25_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_77_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6220_ _1676_ _1867_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_90_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6151_ _0646_ _1695_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__nor2_1
X_5102_ _0616_ _0746_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6082_ _1618_ _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_57_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5033_ _0656_ _0682_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6984_ _0753_ _2593_ VGND VGND VPWR VPWR _2641_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_36_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8723_ clknet_4_10_0_clk _0097_ VGND VGND VPWR VPWR rf.registers\[15\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5935_ net12 _0629_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__or2_1
X_8654_ net148 _4119_ VGND VGND VPWR VPWR _4128_ sky130_fd_sc_hd__and2_1
X_5866_ _0645_ _1524_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__xnor2_2
X_4817_ _0456_ _0459_ _0344_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__mux2_1
X_7605_ _0570_ _3256_ VGND VGND VPWR VPWR _3260_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8585_ _4091_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5797_ _1455_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__buf_6
X_4748_ _0376_ _0352_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__nor2_1
X_7536_ _3190_ _3188_ VGND VGND VPWR VPWR _3191_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4679_ _4186_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__clkbuf_4
X_7467_ net34 _0428_ _3121_ VGND VGND VPWR VPWR _3122_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_43_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6418_ _1832_ _1962_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput15 net15 VGND VGND VPWR VPWR result[14] sky130_fd_sc_hd__buf_2
Xoutput37 net37 VGND VGND VPWR VPWR result[5] sky130_fd_sc_hd__clkbuf_4
Xoutput48 net48 VGND VGND VPWR VPWR seg[6] sky130_fd_sc_hd__clkbuf_4
X_7398_ _3025_ _3054_ _3031_ VGND VGND VPWR VPWR _3055_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_8_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput26 net26 VGND VGND VPWR VPWR result[24] sky130_fd_sc_hd__buf_2
XFILLER_0_101_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6349_ _2007_ _1878_ _1876_ VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__a21o_1
X_8019_ _2272_ _3660_ _3670_ VGND VGND VPWR VPWR _3672_ sky130_fd_sc_hd__or3b_4
XFILLER_0_98_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5720_ _1376_ _1377_ _1372_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5651_ _1210_ _1231_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__or2_1
X_4602_ _4299_ _4301_ _0298_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_60_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5582_ _1231_ _1225_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__nand2_1
X_8370_ reset VGND VGND VPWR VPWR _3995_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_41_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4533_ _0227_ _0229_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__nand2_1
X_7321_ _2972_ _2977_ VGND VGND VPWR VPWR _2978_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7252_ _2859_ _2885_ VGND VGND VPWR VPWR _2909_ sky130_fd_sc_hd__xor2_1
XFILLER_0_40_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6203_ _1703_ _1861_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4464_ _4262_ _4271_ _4272_ VGND VGND VPWR VPWR _4273_ sky130_fd_sc_hd__a21oi_1
X_4395_ rf.registers\[5\]\[8\] _4147_ _4172_ rf.registers\[15\]\[8\] VGND VGND VPWR
+ VPWR _4204_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7183_ _2839_ _2808_ VGND VGND VPWR VPWR _2840_ sky130_fd_sc_hd__nor2_1
X_6134_ _1741_ _1746_ _1791_ _1792_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__a31o_1
XFILLER_0_84_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6065_ _1599_ _1722_ _1723_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__mux2_2
X_5016_ _0673_ _0648_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6967_ _2613_ _2617_ _2622_ _2623_ VGND VGND VPWR VPWR _2624_ sky130_fd_sc_hd__a31o_1
X_8706_ clknet_4_7_0_clk _0080_ VGND VGND VPWR VPWR rf.registers\[25\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_5918_ _1539_ _1576_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__xnor2_1
X_6898_ _2553_ _2531_ _2517_ _2492_ _2554_ VGND VGND VPWR VPWR _2555_ sky130_fd_sc_hd__o221a_1
XFILLER_0_48_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8637_ _4107_ VGND VGND VPWR VPWR _4119_ sky130_fd_sc_hd__clkbuf_2
X_5849_ _1362_ _1367_ _1507_ _1399_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__a31oi_1
X_8568_ _4082_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
X_7519_ _0515_ _3170_ _3162_ VGND VGND VPWR VPWR _3174_ sky130_fd_sc_hd__o21ai_1
X_8499_ net210 _4056_ VGND VGND VPWR VPWR _4062_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7870_ _3511_ _3522_ _3512_ VGND VGND VPWR VPWR _3523_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_85_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6821_ _2475_ _2477_ VGND VGND VPWR VPWR _2478_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_18_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6752_ _2408_ VGND VGND VPWR VPWR _2409_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_45_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6683_ _1618_ _2339_ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__xnor2_1
X_5703_ net264 _1360_ _1361_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__or3_1
XFILLER_0_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5634_ _1290_ _1291_ _0650_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__a21oi_1
X_8422_ net236 _0533_ _4019_ VGND VGND VPWR VPWR _4021_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8353_ _3984_ _3985_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold100 rf.registers\[5\]\[8\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7304_ _2928_ _2941_ VGND VGND VPWR VPWR _2961_ sky130_fd_sc_hd__xor2_1
XFILLER_0_53_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5565_ _1120_ _1175_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8284_ _3935_ _3936_ _3659_ VGND VGND VPWR VPWR _3937_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_96_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold122 rf.registers\[5\]\[3\] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
Xhold144 rf.registers\[15\]\[6\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 rf.registers\[5\]\[9\] VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
X_4516_ _4208_ _4323_ _4324_ VGND VGND VPWR VPWR _4325_ sky130_fd_sc_hd__o21ai_1
Xhold111 rf.registers\[10\]\[16\] VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
X_5496_ _1154_ _1060_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__xnor2_1
Xhold166 rf.registers\[25\]\[7\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 rf.registers\[25\]\[30\] VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
X_7235_ _2873_ net53 VGND VGND VPWR VPWR _2892_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold177 display.refresh_counter\[16\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
X_4447_ _4252_ _4254_ VGND VGND VPWR VPWR _4256_ sky130_fd_sc_hd__nand2_1
Xhold188 rf.registers\[15\]\[2\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
X_7166_ _2798_ _2805_ _2812_ _2815_ _1262_ VGND VGND VPWR VPWR _2823_ sky130_fd_sc_hd__a311oi_2
XFILLER_0_95_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4378_ _4143_ _4180_ _4153_ VGND VGND VPWR VPWR _4187_ sky130_fd_sc_hd__and3_2
X_6117_ _1775_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__inv_2
X_7097_ _2729_ _2745_ _2751_ _2752_ _2753_ VGND VGND VPWR VPWR _2754_ sky130_fd_sc_hd__o311a_1
X_6048_ _0573_ net83 _1700_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_44_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7999_ _3107_ _3646_ VGND VGND VPWR VPWR _3652_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_105_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5350_ _1001_ _0944_ _0943_ _0948_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__or4b_4
XFILLER_0_23_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5281_ _0910_ _0939_ _0872_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__a21oi_4
X_7020_ net19 _2401_ _2676_ VGND VGND VPWR VPWR _2677_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7922_ _3555_ _3565_ VGND VGND VPWR VPWR _3575_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7853_ _3505_ _3494_ _3496_ VGND VGND VPWR VPWR _3506_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6804_ _2439_ _2441_ VGND VGND VPWR VPWR _2461_ sky130_fd_sc_hd__and2_1
X_4996_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__buf_6
X_7784_ _3436_ _3434_ VGND VGND VPWR VPWR _3437_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6735_ _2391_ VGND VGND VPWR VPWR _2392_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_98_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6666_ _2123_ _2322_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6597_ _0631_ _2236_ VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__xnor2_1
X_8405_ net251 _0569_ _4008_ VGND VGND VPWR VPWR _4012_ sky130_fd_sc_hd__mux2_1
X_5617_ _0628_ _1274_ _1252_ _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_103_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5548_ _0649_ _1206_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__and2_1
X_8336_ _3974_ net130 VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__nor2_1
X_8267_ _3889_ _3895_ _3888_ VGND VGND VPWR VPWR _3920_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7218_ _2874_ VGND VGND VPWR VPWR _2875_ sky130_fd_sc_hd__inv_2
X_5479_ _1134_ _1129_ _1126_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a21o_1
X_8198_ _3772_ _3848_ _3850_ net9 VGND VGND VPWR VPWR _3851_ sky130_fd_sc_hd__a211o_1
X_7149_ _2747_ _2756_ _2777_ _2766_ _2765_ VGND VGND VPWR VPWR _2806_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_57_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout61 net30 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4850_ _4285_ _0305_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6520_ _2161_ _2162_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_72_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4781_ _4256_ _4255_ _0319_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6451_ _2066_ _2067_ _2069_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_70_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6382_ _1929_ _1972_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__or2b_1
XFILLER_0_70_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5402_ _1032_ _1048_ _1049_ _0971_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__a211o_1
X_8121_ _2124_ _3747_ VGND VGND VPWR VPWR _3774_ sky130_fd_sc_hd__nand2_1
X_5333_ _0986_ _0980_ _0976_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__a31o_1
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8052_ _1856_ _3688_ VGND VGND VPWR VPWR _3705_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_81_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5264_ _0657_ _0659_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__or2_1
X_5195_ _0660_ _0770_ _0655_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__o21ai_4
X_7003_ _2617_ _2622_ _2613_ VGND VGND VPWR VPWR _2660_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_92_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7905_ _3541_ _3553_ VGND VGND VPWR VPWR _3558_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_54_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_90_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7836_ _3486_ _3488_ VGND VGND VPWR VPWR _3489_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4979_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__buf_4
X_7767_ _3418_ _3415_ _3419_ VGND VGND VPWR VPWR _3420_ sky130_fd_sc_hd__mux2_1
X_6718_ _2242_ _2373_ _2374_ VGND VGND VPWR VPWR _2375_ sky130_fd_sc_hd__a21oi_2
X_7698_ _3329_ _3280_ _3342_ VGND VGND VPWR VPWR _3351_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_33_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload3 clknet_4_3_0_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__inv_6
X_6649_ _2305_ _2306_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__nor2b_1
XFILLER_0_61_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8319_ _3808_ VGND VGND VPWR VPWR _3968_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_6_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5951_ _1608_ _1602_ _1609_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_75_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4902_ net66 _4156_ _0577_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8670_ _4136_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5882_ _1534_ _1432_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7621_ _3269_ _3273_ _3271_ VGND VGND VPWR VPWR _3276_ sky130_fd_sc_hd__a21oi_1
X_4833_ _0515_ _4157_ _0521_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__a21o_1
X_4764_ _0454_ _0457_ _4199_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7552_ _3202_ _3206_ VGND VGND VPWR VPWR _3207_ sky130_fd_sc_hd__nand2_1
X_6503_ _2019_ _2020_ VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7483_ _0468_ _3136_ VGND VGND VPWR VPWR _3138_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_31_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6434_ _1958_ _1964_ _2080_ _2091_ _2092_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__o221a_1
X_4695_ _0390_ _0326_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6365_ _2021_ _2023_ _1961_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__mux2_4
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8104_ _2276_ _3756_ VGND VGND VPWR VPWR _3757_ sky130_fd_sc_hd__xnor2_1
X_6296_ _1810_ _1825_ _1829_ _1809_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__o31a_1
X_5316_ _0971_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8035_ _2260_ _3687_ net96 VGND VGND VPWR VPWR _3688_ sky130_fd_sc_hd__mux2_4
X_5247_ _0657_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__buf_4
X_5178_ _0777_ _0779_ _0789_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__a21bo_1
Xhold59 display.refresh_counter\[9\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 display.refresh_counter\[0\] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8799_ clknet_4_9_0_clk _0173_ VGND VGND VPWR VPWR rf.registers\[10\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_7819_ _3379_ _3460_ _3458_ _3471_ VGND VGND VPWR VPWR _3472_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_81_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4480_ _4286_ _4288_ VGND VGND VPWR VPWR _4289_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_77_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6150_ _1680_ _1723_ _1807_ _1808_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__o22a_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5101_ _0749_ _0755_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a21oi_1
X_6081_ _1616_ _1739_ _1694_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__mux2_2
X_5032_ _0648_ _0682_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__nor2_2
XFILLER_0_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6983_ _2633_ _2634_ _2627_ _2638_ _2639_ VGND VGND VPWR VPWR _2640_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_36_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8722_ clknet_4_9_0_clk _0096_ VGND VGND VPWR VPWR rf.registers\[15\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_5934_ _0570_ _0620_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__nor2_1
X_8653_ _4127_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
X_5865_ _1520_ _1523_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__or2_4
XFILLER_0_48_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4816_ _0453_ _0455_ _0369_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__mux2_1
X_7604_ _3257_ _3258_ VGND VGND VPWR VPWR _3259_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8584_ net249 _4083_ VGND VGND VPWR VPWR _4091_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5796_ _1454_ _1450_ _1385_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__o21a_4
X_4747_ _0348_ _0350_ _0367_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7535_ _3189_ _3187_ VGND VGND VPWR VPWR _3190_ sky130_fd_sc_hd__nor2_1
X_4678_ _4268_ _0374_ _0335_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__mux2_1
X_7466_ net34 _0388_ _0428_ VGND VGND VPWR VPWR _3121_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_31_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6417_ _1795_ _2075_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__and2_1
X_7397_ _3026_ _3022_ _3028_ VGND VGND VPWR VPWR _3054_ sky130_fd_sc_hd__o21a_1
Xoutput38 net38 VGND VGND VPWR VPWR result[6] sky130_fd_sc_hd__clkbuf_4
X_6348_ _2005_ _2006_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_8_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput16 net64 VGND VGND VPWR VPWR result[15] sky130_fd_sc_hd__buf_2
Xoutput27 net27 VGND VGND VPWR VPWR result[25] sky130_fd_sc_hd__buf_2
X_6279_ _1597_ _1900_ _1904_ _1937_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__o31ai_1
X_8018_ net96 _3670_ _2272_ VGND VGND VPWR VPWR _3671_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_17_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5650_ _0650_ _1308_ _1104_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__o21ai_2
X_4601_ _4305_ _0296_ _0297_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5581_ _1239_ _1231_ _1179_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_41_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4532_ _0224_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__or2_1
X_7320_ _2975_ _2976_ VGND VGND VPWR VPWR _2977_ sky130_fd_sc_hd__nand2_1
X_7251_ net52 _2907_ _2393_ _2889_ VGND VGND VPWR VPWR _2908_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_13_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4463_ rf.registers\[25\]\[23\] _4166_ _4176_ rf.registers\[10\]\[23\] VGND VGND
+ VPWR VPWR _4272_ sky130_fd_sc_hd__a22oi_4
X_6202_ _1676_ _1854_ _1718_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4394_ rf.registers\[5\]\[6\] _4147_ _4171_ rf.registers\[15\]\[6\] VGND VGND VPWR
+ VPWR _4203_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7182_ _2391_ _2838_ VGND VGND VPWR VPWR _2839_ sky130_fd_sc_hd__nor2_1
X_6133_ _1689_ _1740_ _1745_ _1766_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__o22ai_1
X_6064_ _1694_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__buf_6
X_5015_ _0673_ _0648_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6966_ _2389_ _2621_ VGND VGND VPWR VPWR _2623_ sky130_fd_sc_hd__nor2_1
X_8705_ clknet_4_13_0_clk _0079_ VGND VGND VPWR VPWR rf.registers\[25\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_5917_ _1543_ _1575_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6897_ _2553_ _2531_ VGND VGND VPWR VPWR _2554_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8636_ _4118_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5848_ _1417_ _1420_ _1396_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8567_ net194 _4072_ VGND VGND VPWR VPWR _4082_ sky130_fd_sc_hd__and2_1
X_5779_ _1421_ _1401_ _1356_ _1437_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__a31o_1
XFILLER_0_44_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7518_ _3172_ VGND VGND VPWR VPWR _3173_ sky130_fd_sc_hd__inv_2
XFILLER_0_31_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8498_ _4061_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_102_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7449_ _3100_ _3104_ VGND VGND VPWR VPWR _3105_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6820_ _0515_ _2398_ _2476_ VGND VGND VPWR VPWR _2477_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_18_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6751_ _2386_ _2406_ _2407_ VGND VGND VPWR VPWR _2408_ sky130_fd_sc_hd__or3b_1
X_6682_ _2223_ _2338_ _2283_ VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5702_ _1244_ net71 _1359_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__and3_1
X_5633_ _1290_ _0650_ _1291_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__and3_1
X_8421_ _4020_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
X_5564_ _1176_ _1145_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__or2b_1
X_8352_ net118 _3982_ VGND VGND VPWR VPWR _3985_ sky130_fd_sc_hd__nor2_1
Xhold101 rf.registers\[10\]\[8\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
X_4515_ rf.registers\[25\]\[10\] _4165_ _4173_ rf.registers\[10\]\[10\] VGND VGND
+ VPWR VPWR _4324_ sky130_fd_sc_hd__a22o_1
X_7303_ _2956_ _2959_ VGND VGND VPWR VPWR _2960_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8283_ _3637_ _3652_ VGND VGND VPWR VPWR _3936_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_96_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold112 rf.registers\[10\]\[0\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 rf.registers\[15\]\[7\] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 rf.registers\[15\]\[30\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
X_5495_ _1064_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__nand2_1
Xhold156 rf.registers\[25\]\[5\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold167 rf.registers\[25\]\[6\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
X_7234_ _0570_ _2403_ VGND VGND VPWR VPWR _2891_ sky130_fd_sc_hd__nor2_1
Xhold145 rf.registers\[10\]\[31\] VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
X_4446_ _4252_ _4254_ VGND VGND VPWR VPWR _4255_ sky130_fd_sc_hd__or2_1
X_4377_ _4185_ VGND VGND VPWR VPWR _4186_ sky130_fd_sc_hd__clkbuf_4
Xhold189 rf.registers\[25\]\[16\] VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
Xhold178 rf.registers\[10\]\[27\] VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
X_7165_ net15 _2402_ VGND VGND VPWR VPWR _2822_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6116_ _1641_ _1642_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__nand2_1
X_7096_ net64 _2390_ VGND VGND VPWR VPWR _2753_ sky130_fd_sc_hd__nor2_1
X_6047_ _1699_ _1700_ _1705_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__a21oi_1
X_7998_ _3644_ _3648_ _3650_ VGND VGND VPWR VPWR _3651_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_95_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6949_ _2583_ VGND VGND VPWR VPWR _2606_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8619_ net140 _4108_ VGND VGND VPWR VPWR _4110_ sky130_fd_sc_hd__or2b_1
XFILLER_0_17_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5280_ _0915_ _0922_ _0929_ _0936_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__a41oi_4
XFILLER_0_49_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7921_ _3566_ VGND VGND VPWR VPWR _3574_ sky130_fd_sc_hd__inv_2
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7852_ _3494_ _3498_ VGND VGND VPWR VPWR _3505_ sky130_fd_sc_hd__nand2_1
X_6803_ _2398_ _2459_ VGND VGND VPWR VPWR _2460_ sky130_fd_sc_hd__nor2_1
X_4995_ display.refresh_counter\[18\] display.refresh_counter\[19\] VGND VGND VPWR
+ VPWR _0654_ sky130_fd_sc_hd__and2b_1
X_7783_ _3431_ _3435_ VGND VGND VPWR VPWR _3436_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6734_ _2390_ VGND VGND VPWR VPWR _2391_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_98_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6665_ _2128_ _2314_ _2221_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_73_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8404_ _4011_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6596_ net7 _2251_ _2252_ _2253_ VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__a22oi_2
X_5616_ _0971_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__buf_4
XFILLER_0_14_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5547_ _1103_ _1205_ net69 VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__mux2_1
X_8335_ display.refresh_counter\[4\] _3972_ net129 VGND VGND VPWR VPWR _3975_ sky130_fd_sc_hd__a21oi_1
X_8266_ _3913_ _3915_ _3918_ VGND VGND VPWR VPWR _3919_ sky130_fd_sc_hd__or3_4
X_5478_ _1126_ _1134_ _1129_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__nand3_1
X_7217_ _2870_ _2872_ _2873_ VGND VGND VPWR VPWR _2874_ sky130_fd_sc_hd__nand3_1
X_4429_ rf.registers\[5\]\[29\] _4149_ _4177_ rf.registers\[15\]\[29\] VGND VGND VPWR
+ VPWR _4238_ sky130_fd_sc_hd__a22o_1
X_8197_ _3849_ _3826_ VGND VGND VPWR VPWR _3850_ sky130_fd_sc_hd__nor2_1
X_7148_ _2391_ _2804_ VGND VGND VPWR VPWR _2805_ sky130_fd_sc_hd__nand2_1
X_7079_ _2716_ _2723_ _2734_ _2735_ VGND VGND VPWR VPWR _2736_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_100_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout62 net23 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_2
XFILLER_0_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4780_ _4256_ _4255_ _0319_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__nand3_1
XFILLER_0_82_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload10 clknet_4_11_0_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__inv_6
X_6450_ _0647_ _2099_ _2108_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_82_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6381_ _1856_ _2039_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__xnor2_1
X_5401_ _1056_ _1057_ _1059_ _0952_ _0954_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__a32o_1
X_8120_ _3736_ _3741_ _3766_ _3772_ VGND VGND VPWR VPWR _3773_ sky130_fd_sc_hd__and4bb_1
X_5332_ _0990_ _0980_ _0985_ _0981_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8051_ _3702_ _3696_ _3703_ VGND VGND VPWR VPWR _3704_ sky130_fd_sc_hd__a21bo_1
X_5263_ _0920_ _0921_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__nor2_1
X_5194_ _0851_ _0839_ _0852_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__a21oi_4
X_7002_ _2632_ _2644_ _2646_ _2648_ _2650_ VGND VGND VPWR VPWR _2659_ sky130_fd_sc_hd__a41oi_4
XFILLER_0_92_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7904_ _3541_ _3556_ VGND VGND VPWR VPWR _3557_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_54_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7835_ _3479_ _3487_ _3473_ VGND VGND VPWR VPWR _3488_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_102_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4978_ _0636_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__buf_6
X_7766_ _3404_ _3409_ VGND VGND VPWR VPWR _3419_ sky130_fd_sc_hd__xnor2_1
X_6717_ _2106_ _2258_ _2233_ _2107_ VGND VGND VPWR VPWR _2374_ sky130_fd_sc_hd__o31a_1
XFILLER_0_73_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7697_ _3348_ _1570_ _3329_ _3349_ VGND VGND VPWR VPWR _3350_ sky130_fd_sc_hd__a211o_1
XFILLER_0_34_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload4 clknet_4_4_0_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__inv_6
X_6648_ _2302_ _2304_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8318_ _3966_ _3967_ _3810_ VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__a21oi_1
X_6579_ net35 net32 net21 net10 VGND VGND VPWR VPWR _2238_ sky130_fd_sc_hd__or4_2
X_8249_ _1856_ _3901_ VGND VGND VPWR VPWR _3902_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_6_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5950_ _0636_ _1607_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__and2_1
X_4901_ _0550_ _0283_ _0576_ _0491_ _0469_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__a32o_1
XFILLER_0_62_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7620_ _3267_ _3274_ VGND VGND VPWR VPWR _3275_ sky130_fd_sc_hd__xnor2_1
X_5881_ _1431_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__inv_2
XFILLER_0_47_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4832_ _4158_ _0516_ _0517_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a31o_1
X_4763_ _0455_ _0456_ _0344_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7551_ _3193_ _3196_ _3199_ VGND VGND VPWR VPWR _3206_ sky130_fd_sc_hd__a21o_1
X_4694_ _4168_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__clkbuf_4
X_6502_ _1988_ _2004_ VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7482_ _0468_ _3136_ VGND VGND VPWR VPWR _3137_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_31_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6433_ _0647_ _1949_ _1957_ net114 VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__a31o_1
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6364_ _1877_ _2022_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8103_ _3660_ _3754_ _3755_ VGND VGND VPWR VPWR _3756_ sky130_fd_sc_hd__o21ai_1
X_6295_ _1809_ _1810_ _1825_ _1829_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__nor4_1
X_5315_ _0870_ _0973_ _0941_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__mux2_4
X_8034_ _3664_ _3686_ VGND VGND VPWR VPWR _3687_ sky130_fd_sc_hd__or2b_1
X_5246_ _0858_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5177_ _0794_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__xnor2_1
Xhold49 display.refresh_counter\[14\] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8867_ clknet_4_5_0_clk _0010_ VGND VGND VPWR VPWR display.refresh_counter\[19\]
+ sky130_fd_sc_hd__dfxtp_4
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8798_ clknet_4_9_0_clk _0172_ VGND VGND VPWR VPWR rf.registers\[10\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7818_ _3379_ _3462_ _3460_ VGND VGND VPWR VPWR _3471_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_81_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7749_ _3396_ _3398_ _3401_ _3394_ VGND VGND VPWR VPWR _3402_ sky130_fd_sc_hd__a22o_1
XFILLER_0_34_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5100_ _0648_ _0758_ _0748_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6080_ _1617_ _1738_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5031_ _0677_ _0689_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_0_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8721_ clknet_4_10_0_clk _0095_ VGND VGND VPWR VPWR rf.registers\[15\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_88_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6982_ _0876_ _2400_ VGND VGND VPWR VPWR _2639_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_36_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5933_ _0570_ _1569_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__nor2_4
X_8652_ net195 _4119_ VGND VGND VPWR VPWR _4127_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5864_ _1456_ _1507_ _1367_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8583_ _4090_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
X_7603_ _3252_ _3255_ VGND VGND VPWR VPWR _3258_ sky130_fd_sc_hd__or2_1
X_4815_ net26 VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7534_ _3179_ _3184_ VGND VGND VPWR VPWR _3189_ sky130_fd_sc_hd__xnor2_1
X_5795_ _0660_ _0770_ _0926_ _1452_ _1453_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__a2111o_1
X_4746_ _0439_ _0440_ _0369_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__mux2_1
X_7465_ _2384_ _3116_ _3119_ VGND VGND VPWR VPWR _3120_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4677_ rf.registers\[25\]\[25\] _4167_ _4177_ rf.registers\[10\]\[25\] VGND VGND
+ VPWR VPWR _0374_ sky130_fd_sc_hd__a22o_1
X_7396_ _3050_ _3052_ VGND VGND VPWR VPWR _3053_ sky130_fd_sc_hd__or2_2
X_6416_ _1893_ _2074_ _1964_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput39 net39 VGND VGND VPWR VPWR result[7] sky130_fd_sc_hd__clkbuf_4
X_6347_ _1845_ _1851_ _1859_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_8_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput17 net17 VGND VGND VPWR VPWR result[16] sky130_fd_sc_hd__buf_2
Xoutput28 net28 VGND VGND VPWR VPWR result[26] sky130_fd_sc_hd__buf_2
X_6278_ _1618_ _1895_ _1898_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__nand3_1
XFILLER_0_11_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8017_ _2282_ _3669_ VGND VGND VPWR VPWR _3670_ sky130_fd_sc_hd__nand2_1
X_5229_ net88 _0854_ _0822_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__o21a_1
XFILLER_0_94_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4600_ _4299_ _4301_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__xor2_1
XFILLER_0_53_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5580_ _1158_ _1174_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_41_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4531_ _4163_ _4201_ _4203_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7250_ _2393_ _2906_ VGND VGND VPWR VPWR _2907_ sky130_fd_sc_hd__nand2_1
X_4462_ _4228_ _4229_ _4261_ _4227_ VGND VGND VPWR VPWR _4271_ sky130_fd_sc_hd__o31ai_1
X_6201_ _1845_ _1851_ _1857_ _1858_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4393_ rf.registers\[5\]\[7\] _4147_ _4172_ rf.registers\[15\]\[7\] VGND VGND VPWR
+ VPWR _4202_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7181_ _2806_ _2807_ VGND VGND VPWR VPWR _2838_ sky130_fd_sc_hd__and2_1
X_6132_ _1752_ _1790_ _1751_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__a21oi_1
X_6063_ _1600_ _1721_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__xor2_1
X_5014_ net61 VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__inv_2
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6965_ _2400_ _2621_ VGND VGND VPWR VPWR _2622_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8704_ clknet_4_13_0_clk _0078_ VGND VGND VPWR VPWR rf.registers\[25\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_5916_ _1527_ _1532_ _1545_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8635_ net200 _4108_ VGND VGND VPWR VPWR _4118_ sky130_fd_sc_hd__and2_1
X_6896_ _2399_ _2492_ VGND VGND VPWR VPWR _2553_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5847_ _1503_ _1477_ _1504_ _1472_ _1505_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__a311o_1
XFILLER_0_106_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8566_ _4081_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5778_ _1427_ _1428_ _1432_ _1436_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__or4_1
XFILLER_0_71_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4729_ _0416_ _0424_ _0238_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7517_ net24 _3171_ VGND VGND VPWR VPWR _3172_ sky130_fd_sc_hd__nor2_1
X_8497_ net164 _4056_ VGND VGND VPWR VPWR _4061_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7448_ net36 _2395_ _3103_ _3101_ VGND VGND VPWR VPWR _3104_ sky130_fd_sc_hd__o31a_1
XFILLER_0_101_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7379_ _3007_ _3012_ _3031_ VGND VGND VPWR VPWR _3036_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6750_ _0428_ net61 net29 VGND VGND VPWR VPWR _2407_ sky130_fd_sc_hd__or3_1
X_5701_ _1335_ _1359_ _1244_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__a21oi_1
X_6681_ _2336_ _2337_ VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5632_ _1117_ net68 VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__or2_1
X_8420_ net187 _0539_ _4019_ VGND VGND VPWR VPWR _4020_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8351_ display.refresh_counter\[12\] _3982_ VGND VGND VPWR VPWR _3984_ sky130_fd_sc_hd__and2_1
X_5563_ _1124_ _1194_ _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4514_ _4205_ _4206_ _4207_ _4187_ VGND VGND VPWR VPWR _4323_ sky130_fd_sc_hd__o22a_1
X_7302_ _2929_ _2939_ _2923_ VGND VGND VPWR VPWR _2959_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_13_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8282_ _3651_ _3934_ _3637_ _2396_ _3654_ VGND VGND VPWR VPWR _3935_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_96_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold124 rf.registers\[5\]\[7\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 rf.registers\[5\]\[12\] VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 rf.registers\[5\]\[11\] VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
Xhold102 rf.registers\[5\]\[20\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5494_ _1035_ _1152_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__nand2_1
Xhold168 rf.registers\[25\]\[8\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
X_7233_ _2393_ _2889_ VGND VGND VPWR VPWR _2890_ sky130_fd_sc_hd__xnor2_1
Xhold146 rf.registers\[25\]\[26\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
Xhold157 rf.registers\[15\]\[23\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
X_4445_ _4234_ _4253_ VGND VGND VPWR VPWR _4254_ sky130_fd_sc_hd__xnor2_1
X_4376_ rf.registers\[5\]\[1\] net60 _4153_ _4184_ VGND VGND VPWR VPWR _4185_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold179 rf.registers\[10\]\[25\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
X_7164_ _1262_ _2391_ VGND VGND VPWR VPWR _2821_ sky130_fd_sc_hd__nand2_1
X_6115_ _0637_ _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_13_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7095_ _2710_ _2736_ _2740_ _2728_ VGND VGND VPWR VPWR _2752_ sky130_fd_sc_hd__a211o_1
X_6046_ _1594_ _1704_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7997_ _3645_ _3649_ _3100_ _3116_ VGND VGND VPWR VPWR _3650_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_95_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6948_ _2589_ _2592_ VGND VGND VPWR VPWR _2605_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6879_ _2535_ _2501_ VGND VGND VPWR VPWR _2536_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8618_ _4109_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8549_ net179 _4072_ VGND VGND VPWR VPWR _4073_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7920_ _3568_ _3571_ VGND VGND VPWR VPWR _3573_ sky130_fd_sc_hd__nor2_1
X_7851_ _3372_ _3503_ VGND VGND VPWR VPWR _3504_ sky130_fd_sc_hd__nor2_1
X_6802_ _2436_ _2458_ VGND VGND VPWR VPWR _2459_ sky130_fd_sc_hd__and2b_1
X_4994_ _0652_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__buf_6
X_7782_ _3425_ _3428_ VGND VGND VPWR VPWR _3435_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6733_ _2389_ VGND VGND VPWR VPWR _2390_ sky130_fd_sc_hd__buf_2
XFILLER_0_46_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6664_ _2319_ _2320_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_98_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8403_ net237 _0572_ _4008_ VGND VGND VPWR VPWR _4011_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5615_ _1266_ _1273_ net68 VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__mux2_1
X_6595_ _0587_ net6 VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5546_ _1204_ _1111_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__xor2_1
X_8334_ net261 display.refresh_counter\[5\] _3972_ VGND VGND VPWR VPWR _3974_ sky130_fd_sc_hd__and3_1
X_8265_ _3902_ _3907_ _3917_ VGND VGND VPWR VPWR _3918_ sky130_fd_sc_hd__and3_1
X_5477_ _1133_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7216_ _0570_ _2403_ VGND VGND VPWR VPWR _2873_ sky130_fd_sc_hd__nand2_1
X_4428_ rf.registers\[5\]\[28\] _4149_ _4176_ rf.registers\[15\]\[28\] VGND VGND VPWR
+ VPWR _4237_ sky130_fd_sc_hd__a22o_1
X_8196_ _3769_ VGND VGND VPWR VPWR _3849_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4359_ net1 _4152_ VGND VGND VPWR VPWR _4168_ sky130_fd_sc_hd__nand2_1
X_7147_ _2799_ _2803_ _2779_ VGND VGND VPWR VPWR _2804_ sky130_fd_sc_hd__mux2_1
X_7078_ _2390_ _2722_ VGND VGND VPWR VPWR _2735_ sky130_fd_sc_hd__nor2_1
X_6029_ _1684_ _1687_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_57_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout63 net18 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload11 clknet_4_12_0_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__inv_6
X_6380_ _2036_ _2038_ _1961_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__mux2_1
X_5400_ _0955_ _1058_ _1031_ _0872_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__a211o_1
X_5331_ _0974_ _0987_ _0800_ _0989_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8050_ _2287_ _3695_ VGND VGND VPWR VPWR _3703_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_93_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5262_ _0649_ _0919_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__nor2_1
X_7001_ _2657_ VGND VGND VPWR VPWR _2658_ sky130_fd_sc_hd__inv_2
X_5193_ _0388_ _0657_ _0660_ _0770_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__a22o_1
X_7903_ _3552_ _3555_ VGND VGND VPWR VPWR _3556_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_54_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7834_ _3479_ _3476_ VGND VGND VPWR VPWR _3487_ sky130_fd_sc_hd__nor2_1
X_7765_ _3415_ _3417_ VGND VGND VPWR VPWR _3418_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_102_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6716_ _2258_ _2233_ VGND VGND VPWR VPWR _2373_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4977_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__buf_4
XFILLER_0_73_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7696_ _3348_ _2939_ VGND VGND VPWR VPWR _3349_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload5 clknet_4_5_0_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_6
X_6647_ _2302_ _2304_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6578_ _2214_ _2207_ VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__or2b_1
X_8317_ _3957_ _3962_ _3960_ VGND VGND VPWR VPWR _3967_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5529_ _1185_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__xor2_1
X_8248_ _3695_ _3900_ _3822_ VGND VGND VPWR VPWR _3901_ sky130_fd_sc_hd__mux2_4
X_8179_ _3736_ _3824_ VGND VGND VPWR VPWR _3832_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_6_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4900_ _0282_ _4329_ _0280_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__or3_1
XFILLER_0_62_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5880_ _1484_ _1538_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__xnor2_1
X_4831_ _4200_ _0370_ _0518_ _0345_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__o221a_1
X_4762_ _0414_ _0392_ _0339_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7550_ net19 _3204_ VGND VGND VPWR VPWR _3205_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6501_ _2158_ _2159_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__and2_1
X_7481_ _3130_ _3133_ _3135_ VGND VGND VPWR VPWR _3136_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_31_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4693_ _0325_ _4246_ _0324_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__or3_1
X_6432_ _1963_ _1968_ _2085_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__and3_1
X_8102_ _2372_ _2377_ _2382_ _2358_ VGND VGND VPWR VPWR _3755_ sky130_fd_sc_hd__a211o_1
XFILLER_0_87_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6363_ _1873_ _2008_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__nor2_1
X_6294_ _1952_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__buf_4
X_5314_ _0964_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8033_ _2254_ _2261_ VGND VGND VPWR VPWR _3686_ sky130_fd_sc_hd__nand2_1
X_5245_ _0861_ _0902_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__o21ba_1
X_5176_ _0831_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_3_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8866_ clknet_4_5_0_clk _0009_ VGND VGND VPWR VPWR display.refresh_counter\[18\]
+ sky130_fd_sc_hd__dfxtp_2
XFILLER_0_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8797_ clknet_4_13_0_clk _0171_ VGND VGND VPWR VPWR rf.registers\[10\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_7817_ _3467_ _3469_ VGND VGND VPWR VPWR _3470_ sky130_fd_sc_hd__nand2_1
X_7748_ _3395_ _3400_ VGND VGND VPWR VPWR _3401_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7679_ _3333_ VGND VGND VPWR VPWR _3334_ sky130_fd_sc_hd__buf_2
XFILLER_0_46_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5030_ _0428_ _0687_ _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_69_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6981_ _2635_ _2636_ _2637_ net20 VGND VGND VPWR VPWR _2638_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_88_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8720_ clknet_4_10_0_clk _0094_ VGND VGND VPWR VPWR rf.registers\[15\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_64_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5932_ _1586_ net70 _1590_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8651_ _4126_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5863_ _0635_ _1521_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8582_ net178 _4083_ VGND VGND VPWR VPWR _4090_ sky130_fd_sc_hd__and2_1
X_7602_ _0570_ _3256_ _3251_ VGND VGND VPWR VPWR _3257_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_7_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4814_ _0494_ _4157_ _0504_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__a21o_1
X_5794_ _1310_ _1316_ net100 VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__and3_1
XFILLER_0_90_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4745_ _0342_ _0347_ _0367_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__mux2_1
X_7533_ _3171_ _3182_ _3180_ VGND VGND VPWR VPWR _3188_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4676_ _4257_ _0371_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7464_ _3118_ VGND VGND VPWR VPWR _3119_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7395_ _2395_ _3033_ _3051_ VGND VGND VPWR VPWR _3052_ sky130_fd_sc_hd__a21o_1
X_6415_ _1894_ _2073_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__xor2_1
XFILLER_0_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6346_ _1857_ _1858_ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_8_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput18 net63 VGND VGND VPWR VPWR result[17] sky130_fd_sc_hd__buf_2
Xoutput29 net29 VGND VGND VPWR VPWR result[27] sky130_fd_sc_hd__buf_2
XFILLER_0_3_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8016_ _2267_ _2266_ _3668_ VGND VGND VPWR VPWR _3669_ sky130_fd_sc_hd__or3b_1
X_6277_ _1933_ _1934_ _1924_ _1930_ _1935_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__a41o_1
X_5228_ _0824_ _0805_ _0820_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_87_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5159_ _0800_ _0804_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8849_ clknet_4_0_0_clk _0011_ VGND VGND VPWR VPWR display.refresh_counter\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap60 _4146_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_61_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4530_ rf.registers\[25\]\[6\] _4164_ _4172_ rf.registers\[10\]\[6\] VGND VGND VPWR
+ VPWR _0227_ sky130_fd_sc_hd__a22o_1
XFILLER_0_80_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4461_ _4263_ _4269_ VGND VGND VPWR VPWR _4270_ sky130_fd_sc_hd__nand2_1
X_6200_ _1847_ _1850_ _1676_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7180_ _2835_ _2836_ VGND VGND VPWR VPWR _2837_ sky130_fd_sc_hd__or2_1
X_4392_ _4190_ _4191_ _4200_ VGND VGND VPWR VPWR _4201_ sky130_fd_sc_hd__or3_1
X_6131_ _1723_ _1755_ _1756_ _1766_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__a211o_1
XFILLER_0_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6062_ _1589_ _1596_ _1601_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__a21oi_1
X_5013_ _0480_ _0624_ net29 VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_49_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6964_ _2619_ _2615_ _2620_ _2618_ VGND VGND VPWR VPWR _2621_ sky130_fd_sc_hd__a22o_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8703_ clknet_4_12_0_clk _0077_ VGND VGND VPWR VPWR rf.registers\[25\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_6895_ _2547_ _2526_ _2550_ _2551_ VGND VGND VPWR VPWR _2552_ sky130_fd_sc_hd__a31o_1
X_5915_ _1005_ _1573_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__and2_1
X_8634_ _4117_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
X_5846_ _0651_ _1461_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8565_ net168 _4072_ VGND VGND VPWR VPWR _4081_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5777_ _1294_ _1435_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__xnor2_1
X_4728_ _0420_ _0423_ _0383_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7516_ _0515_ _3170_ VGND VGND VPWR VPWR _3171_ sky130_fd_sc_hd__xnor2_1
X_8496_ _4060_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__clkbuf_1
X_7447_ _0591_ _3102_ _3093_ VGND VGND VPWR VPWR _3103_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4659_ _0345_ _0355_ _4199_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7378_ _3005_ _3034_ VGND VGND VPWR VPWR _3035_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_101_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6329_ _1970_ _1987_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_95_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5700_ _1345_ _1357_ _1358_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__o21ba_1
X_6680_ _2156_ _2219_ _2226_ VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__a21oi_1
X_5631_ _1258_ _1288_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__or3_1
X_8350_ _3982_ net125 VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__nor2_1
X_5562_ _1214_ _1220_ net264 VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__a21oi_4
X_8281_ _3655_ _3653_ VGND VGND VPWR VPWR _3934_ sky130_fd_sc_hd__or2_1
X_4513_ _4319_ _4321_ VGND VGND VPWR VPWR _4322_ sky130_fd_sc_hd__nand2_1
X_7301_ _2917_ _2957_ VGND VGND VPWR VPWR _2958_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold103 rf.registers\[5\]\[6\] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 rf.registers\[5\]\[16\] VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
X_7232_ _2878_ _2888_ VGND VGND VPWR VPWR _2889_ sky130_fd_sc_hd__xnor2_1
X_5493_ _1033_ _1063_ _1054_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__a21o_1
Xhold114 rf.registers\[5\]\[24\] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_96_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold136 rf.registers\[15\]\[5\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 rf.registers\[15\]\[11\] VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold158 rf.registers\[15\]\[16\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4444_ _4179_ _4233_ _4235_ VGND VGND VPWR VPWR _4253_ sky130_fd_sc_hd__a21oi_1
X_4375_ imem.address\[0\] _4183_ _4143_ VGND VGND VPWR VPWR _4184_ sky130_fd_sc_hd__o21ai_1
Xhold169 rf.registers\[25\]\[21\] VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
X_7163_ _2402_ _2819_ VGND VGND VPWR VPWR _2820_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6114_ _1694_ _1770_ _1771_ _1772_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__a31o_1
X_7094_ _0556_ _2402_ VGND VGND VPWR VPWR _2751_ sky130_fd_sc_hd__nor2_1
X_6045_ _0573_ _0629_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7996_ _3100_ _3104_ VGND VGND VPWR VPWR _3649_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_105_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6947_ _2584_ _2578_ _2592_ VGND VGND VPWR VPWR _2604_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6878_ _2388_ _2534_ VGND VGND VPWR VPWR _2535_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8617_ rf.registers\[5\]\[0\] _4108_ VGND VGND VPWR VPWR _4109_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5829_ _1407_ _1487_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8548_ _4071_ VGND VGND VPWR VPWR _4072_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_17_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8479_ _4051_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_99_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7850_ _3500_ _3502_ VGND VGND VPWR VPWR _3503_ sky130_fd_sc_hd__or2_1
X_6801_ _2454_ _2456_ _2457_ VGND VGND VPWR VPWR _2458_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4993_ display.refresh_counter\[19\] display.refresh_counter\[17\] VGND VGND VPWR
+ VPWR _0652_ sky130_fd_sc_hd__and2_4
X_7781_ _3432_ _3426_ _3433_ VGND VGND VPWR VPWR _3434_ sky130_fd_sc_hd__o21a_1
XFILLER_0_81_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6732_ _2388_ VGND VGND VPWR VPWR _2389_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6663_ net9 _2318_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8402_ _4010_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
X_5614_ _1271_ _1272_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__nor2_1
X_6594_ _0630_ VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_6
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5545_ _1097_ _1110_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8333_ net133 _3972_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__xor2_1
X_8264_ net7 _3910_ _3916_ VGND VGND VPWR VPWR _3917_ sky130_fd_sc_hd__a21oi_1
X_5476_ _1085_ _1134_ _1132_ _1089_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8195_ _3780_ net99 _3825_ VGND VGND VPWR VPWR _3848_ sky130_fd_sc_hd__and3_1
X_7215_ _1406_ _2871_ VGND VGND VPWR VPWR _2872_ sky130_fd_sc_hd__xnor2_1
X_4427_ _4233_ _4234_ _4235_ VGND VGND VPWR VPWR _4236_ sky130_fd_sc_hd__or3_1
XFILLER_0_1_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7146_ _2800_ _2802_ VGND VGND VPWR VPWR _2803_ sky130_fd_sc_hd__xnor2_1
X_4358_ _4166_ VGND VGND VPWR VPWR _4167_ sky130_fd_sc_hd__clkbuf_4
X_7077_ _2725_ _2727_ _2729_ _2730_ _2733_ VGND VGND VPWR VPWR _2734_ sky130_fd_sc_hd__o311a_1
X_6028_ _1562_ _1686_ _1570_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7979_ _3094_ _3631_ _3116_ VGND VGND VPWR VPWR _3632_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout64 net16 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkload12 clknet_4_13_0_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__clkinvlp_4
XPHY_EDGE_ROW_41_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5330_ _0864_ net75 _0988_ _0627_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__o211a_1
XFILLER_0_11_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5261_ _0649_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__and2_1
X_7000_ _2400_ _2656_ VGND VGND VPWR VPWR _2657_ sky130_fd_sc_hd__or2_1
X_5192_ _0840_ _0841_ _0849_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__o31a_1
XFILLER_0_48_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_50_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7902_ _3553_ _3554_ VGND VGND VPWR VPWR _3555_ sky130_fd_sc_hd__or2_1
XFILLER_0_92_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7833_ _3484_ _3485_ VGND VGND VPWR VPWR _3486_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7764_ _3402_ _3405_ _3416_ VGND VGND VPWR VPWR _3417_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_102_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6715_ _2335_ _2312_ _2363_ _2371_ VGND VGND VPWR VPWR _2372_ sky130_fd_sc_hd__a31o_4
X_4976_ _0634_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__buf_6
XFILLER_0_46_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7695_ _3347_ VGND VGND VPWR VPWR _3348_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6646_ _2166_ _2303_ _2283_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload6 clknet_4_6_0_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__inv_6
XFILLER_0_104_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6577_ _1486_ _2235_ _2212_ VGND VGND VPWR VPWR _2236_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_104_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8316_ _3808_ _3964_ VGND VGND VPWR VPWR _3966_ sky130_fd_sc_hd__nand2_1
X_5528_ _1093_ _1186_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__nand2_1
X_8247_ _3899_ _3702_ VGND VGND VPWR VPWR _3900_ sky130_fd_sc_hd__xnor2_1
X_5459_ _0660_ _1117_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__and2_1
X_8178_ _3736_ _3824_ VGND VGND VPWR VPWR _3831_ sky130_fd_sc_hd__nor2_1
X_7129_ _2729_ _2745_ _2751_ _2752_ VGND VGND VPWR VPWR _2786_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_69_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4830_ _4150_ _0485_ _0355_ _0357_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a31o_1
XFILLER_0_68_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4761_ _0409_ _0413_ _0367_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__mux2_1
X_6500_ _2071_ _2015_ VGND VGND VPWR VPWR _2159_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7480_ _0388_ _3124_ _3126_ _3134_ VGND VGND VPWR VPWR _3135_ sky130_fd_sc_hd__a31o_1
X_4692_ net33 VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_31_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6431_ _2089_ VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__buf_6
XFILLER_0_70_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6362_ _1867_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__inv_2
X_8101_ _2312_ _2361_ VGND VGND VPWR VPWR _3754_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5313_ _0871_ _0878_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6293_ _1950_ _1837_ _1951_ _1823_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__a211o_1
X_8032_ net6 _3684_ VGND VGND VPWR VPWR _3685_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5244_ _0643_ _0860_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__nor2_1
X_5175_ _0742_ _0833_ _0789_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_3_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8865_ clknet_4_5_0_clk _0008_ VGND VGND VPWR VPWR display.refresh_counter\[17\]
+ sky130_fd_sc_hd__dfxtp_4
X_7816_ _3461_ _3468_ _3456_ VGND VGND VPWR VPWR _3469_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8796_ clknet_4_12_0_clk _0170_ VGND VGND VPWR VPWR rf.registers\[10\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_4959_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__inv_2
X_7747_ _3396_ _3399_ _3398_ VGND VGND VPWR VPWR _3400_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_61_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7678_ _3332_ VGND VGND VPWR VPWR _3333_ sky130_fd_sc_hd__inv_2
X_6629_ _2172_ VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__buf_4
XFILLER_0_34_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_106_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6980_ _2626_ VGND VGND VPWR VPWR _2637_ sky130_fd_sc_hd__inv_2
XFILLER_0_87_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5931_ _0570_ _0629_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8650_ net192 _4119_ VGND VGND VPWR VPWR _4126_ sky130_fd_sc_hd__and2_1
X_5862_ _1519_ _1520_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__xor2_2
X_8581_ _4089_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7601_ _3250_ _3253_ _3255_ VGND VGND VPWR VPWR _3256_ sky130_fd_sc_hd__o21a_1
XFILLER_0_8_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5793_ _1322_ _1320_ _1451_ net264 VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__a211oi_1
X_4813_ _0469_ _0497_ _0503_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__a21o_1
X_4744_ _0338_ _0341_ _0367_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7532_ _0534_ _3186_ VGND VGND VPWR VPWR _3187_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4675_ _4188_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_31_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7463_ _2403_ net4 VGND VGND VPWR VPWR _3118_ sky130_fd_sc_hd__nand2_4
X_7394_ _2395_ _3033_ _3038_ _3044_ VGND VGND VPWR VPWR _3051_ sky130_fd_sc_hd__o22a_1
X_6414_ _1888_ _1977_ _2072_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_98_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6345_ _1994_ _2001_ _2002_ _2003_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_8_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput19 net19 VGND VGND VPWR VPWR result[18] sky130_fd_sc_hd__buf_2
X_6276_ _0630_ _1912_ _1923_ _1922_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__a31o_1
X_8015_ _3664_ _3665_ _3667_ VGND VGND VPWR VPWR _3668_ sky130_fd_sc_hd__o21a_1
X_5227_ _0880_ _0881_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__o21ba_1
X_5158_ _0816_ _0648_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__xnor2_4
X_5089_ _0625_ _0734_ _0707_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_93_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8848_ clknet_4_0_0_clk _0000_ VGND VGND VPWR VPWR display.refresh_counter\[0\] sky130_fd_sc_hd__dfxtp_1
X_8779_ clknet_4_5_0_clk _0153_ _0052_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_34_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4460_ _4232_ _4262_ VGND VGND VPWR VPWR _4269_ sky130_fd_sc_hd__nand2_1
X_4391_ _4194_ _4199_ VGND VGND VPWR VPWR _4200_ sky130_fd_sc_hd__or2_4
XFILLER_0_68_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6130_ _1784_ _1785_ _1787_ _1788_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6061_ _1597_ _1702_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__nand2_1
X_5012_ net28 _0624_ _0669_ _0664_ _0662_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_49_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6963_ _2589_ _2592_ _2609_ _2614_ VGND VGND VPWR VPWR _2620_ sky130_fd_sc_hd__a211o_1
XFILLER_0_75_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8702_ clknet_4_12_0_clk _0076_ VGND VGND VPWR VPWR rf.registers\[25\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_6894_ _2399_ _2545_ _2546_ VGND VGND VPWR VPWR _2551_ sky130_fd_sc_hd__and3_1
X_5914_ _1552_ _1570_ _1571_ _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_91_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8633_ net167 _4108_ VGND VGND VPWR VPWR _4117_ sky130_fd_sc_hd__and2_1
X_5845_ _0636_ _1466_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8564_ _4080_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5776_ _1298_ _1335_ _1434_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4727_ _0421_ _0422_ _0376_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__mux2_1
X_7515_ _3168_ _3163_ _3165_ VGND VGND VPWR VPWR _3170_ sky130_fd_sc_hd__o21a_1
X_8495_ net224 _4056_ VGND VGND VPWR VPWR _4060_ sky130_fd_sc_hd__and2_1
X_7446_ _3069_ _3101_ VGND VGND VPWR VPWR _3102_ sky130_fd_sc_hd__and2_1
X_4658_ _0349_ _0354_ _4182_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7377_ _3013_ _3031_ VGND VGND VPWR VPWR _3034_ sky130_fd_sc_hd__and2b_1
X_4589_ _4325_ _0283_ _0285_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6328_ net113 _1985_ _1986_ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__a21o_1
X_6259_ _1679_ _1786_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5630_ _1196_ _1216_ _1287_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5561_ _1203_ _1219_ _1201_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__a21oi_4
X_8280_ _3932_ _3650_ VGND VGND VPWR VPWR _3933_ sky130_fd_sc_hd__and2b_1
X_4512_ _4317_ _4320_ VGND VGND VPWR VPWR _4321_ sky130_fd_sc_hd__or2_1
X_7300_ _2925_ _2956_ VGND VGND VPWR VPWR _2957_ sky130_fd_sc_hd__xor2_2
XFILLER_0_13_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5492_ _1050_ _1150_ _1116_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__mux2_2
XFILLER_0_26_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold126 rf.registers\[15\]\[10\] VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
Xhold104 rf.registers\[15\]\[13\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 rf.registers\[5\]\[30\] VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dlygate4sd3_1
X_7231_ _2874_ _2876_ net53 VGND VGND VPWR VPWR _2888_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_96_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold148 rf.registers\[25\]\[3\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
Xhold137 rf.registers\[25\]\[1\] VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold159 rf.registers\[10\]\[28\] VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
X_4443_ rf.registers\[25\]\[27\] _4167_ _4241_ rf.registers\[10\]\[27\] VGND VGND
+ VPWR VPWR _4252_ sky130_fd_sc_hd__a22oi_1
X_4374_ rf.registers\[15\]\[1\] VGND VGND VPWR VPWR _4183_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7162_ _2781_ _2817_ _2818_ VGND VGND VPWR VPWR _2819_ sky130_fd_sc_hd__o21ai_1
X_6113_ _1640_ _1692_ _1693_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__and3_1
X_7093_ _2748_ _2749_ VGND VGND VPWR VPWR _2750_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6044_ _1439_ _1702_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7995_ _3646_ _3647_ VGND VGND VPWR VPWR _3648_ sky130_fd_sc_hd__nor2_1
X_6946_ _2561_ _2578_ _2584_ VGND VGND VPWR VPWR _2603_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_105_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6877_ _2499_ _2500_ VGND VGND VPWR VPWR _2534_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8616_ _4107_ VGND VGND VPWR VPWR _4108_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_29_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5828_ _1486_ _1485_ _1408_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__o21ai_1
X_8547_ _4143_ imem.address\[0\] _4168_ _4032_ VGND VGND VPWR VPWR _4071_ sky130_fd_sc_hd__or4_4
XFILLER_0_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5759_ _1370_ _1369_ _1121_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__and3_1
XFILLER_0_51_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8478_ net175 _4045_ VGND VGND VPWR VPWR _4051_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7429_ _3053_ _3056_ VGND VGND VPWR VPWR _3086_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6800_ _2440_ _2436_ _2453_ _2387_ VGND VGND VPWR VPWR _2457_ sky130_fd_sc_hd__o31a_1
X_4992_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__buf_6
X_7780_ _3423_ _3426_ VGND VGND VPWR VPWR _3433_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6731_ _2387_ VGND VGND VPWR VPWR _2388_ sky130_fd_sc_hd__buf_2
X_6662_ net9 _2318_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8401_ net241 _0575_ _4008_ VGND VGND VPWR VPWR _4010_ sky130_fd_sc_hd__mux2_1
X_5613_ _1269_ _1270_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__nor2_1
X_6593_ _0632_ _1486_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8332_ _3972_ _3973_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5544_ _0726_ _0770_ _1200_ _1202_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__o211a_1
X_8263_ _0595_ net6 _2238_ _3912_ VGND VGND VPWR VPWR _3916_ sky130_fd_sc_hd__a211o_1
X_5475_ _1116_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__buf_6
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8194_ _1689_ _3844_ VGND VGND VPWR VPWR _3847_ sky130_fd_sc_hd__or2_1
X_4426_ rf.registers\[5\]\[26\] _4149_ _4176_ rf.registers\[15\]\[26\] VGND VGND VPWR
+ VPWR _4235_ sky130_fd_sc_hd__a22o_1
X_7214_ _2403_ _2854_ VGND VGND VPWR VPWR _2871_ sky130_fd_sc_hd__nand2_1
X_7145_ _2801_ _2772_ VGND VGND VPWR VPWR _2802_ sky130_fd_sc_hd__nor2_1
X_4357_ _4165_ VGND VGND VPWR VPWR _4166_ sky130_fd_sc_hd__clkbuf_4
X_7076_ _2731_ _2732_ VGND VGND VPWR VPWR _2733_ sky130_fd_sc_hd__xnor2_2
X_6027_ _1670_ _1685_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__xnor2_1
X_7978_ _3112_ _3630_ VGND VGND VPWR VPWR _3631_ sky130_fd_sc_hd__nand2_1
X_6929_ _2540_ _2580_ _2585_ _2558_ VGND VGND VPWR VPWR _2586_ sky130_fd_sc_hd__o211a_1
Xfanout65 net14 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_2
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload13 clknet_4_14_0_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__inv_6
XFILLER_0_11_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5260_ _0847_ _0918_ _0856_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__mux2_1
X_5191_ _0800_ _0649_ _0388_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7901_ _3355_ _3546_ VGND VGND VPWR VPWR _3554_ sky130_fd_sc_hd__and2_1
XFILLER_0_78_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7832_ _3478_ _3482_ VGND VGND VPWR VPWR _3485_ sky130_fd_sc_hd__xnor2_1
X_4975_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7763_ _3407_ _3405_ _3402_ VGND VGND VPWR VPWR _3416_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_102_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6714_ _2321_ _2334_ _2368_ _2370_ VGND VGND VPWR VPWR _2371_ sky130_fd_sc_hd__o31ai_2
XFILLER_0_58_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7694_ _3327_ _0614_ VGND VGND VPWR VPWR _3347_ sky130_fd_sc_hd__nand2_1
X_6645_ _2177_ _2298_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload7 clknet_4_7_0_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__clkinvlp_4
X_6576_ _2210_ _2211_ VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__or2_1
X_8315_ _3965_ VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
X_5527_ _1044_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__inv_2
X_8246_ _3703_ _3696_ VGND VGND VPWR VPWR _3899_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5458_ _1034_ _1099_ net69 VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__mux2_1
X_8177_ _3740_ _3811_ _3826_ _3829_ VGND VGND VPWR VPWR _3830_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_70_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4409_ rf.registers\[5\]\[17\] _4148_ _4174_ rf.registers\[15\]\[17\] VGND VGND VPWR
+ VPWR _4218_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5389_ _0956_ _0960_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7128_ _1262_ _2391_ VGND VGND VPWR VPWR _2785_ sky130_fd_sc_hd__nor2_1
X_7059_ _2401_ _2715_ VGND VGND VPWR VPWR _2716_ sky130_fd_sc_hd__or2_1
XFILLER_0_69_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4760_ _0451_ _0453_ _0344_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4691_ net34 _4157_ _0387_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__a21o_1
XFILLER_0_102_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6430_ _2070_ _1980_ _2076_ _2088_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6361_ _2018_ _2016_ _0638_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__and3_1
X_8100_ _2287_ _3752_ VGND VGND VPWR VPWR _3753_ sky130_fd_sc_hd__xnor2_1
X_5312_ _0653_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__buf_6
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6292_ _1817_ _1805_ _1815_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__and3_1
X_8031_ _3666_ _3683_ net96 VGND VGND VPWR VPWR _3684_ sky130_fd_sc_hd__mux2_4
X_5243_ _0893_ _0897_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a21oi_1
X_5174_ _0743_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_67_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8864_ clknet_4_5_0_clk _0007_ VGND VGND VPWR VPWR display.refresh_counter\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_7815_ _3461_ _3458_ VGND VGND VPWR VPWR _3468_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8795_ clknet_4_12_0_clk _0169_ VGND VGND VPWR VPWR rf.registers\[10\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4958_ _0617_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__buf_4
X_7746_ _3333_ _3123_ _3392_ _3387_ _3389_ VGND VGND VPWR VPWR _3399_ sky130_fd_sc_hd__o32a_1
XFILLER_0_46_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4889_ _4315_ _4314_ _0289_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__a21o_1
X_7677_ _0614_ _3331_ VGND VGND VPWR VPWR _3332_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6628_ _2282_ _2285_ _2267_ _2272_ VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__a211o_1
XFILLER_0_34_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6559_ _0647_ _2166_ VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8229_ net92 _3880_ _3679_ VGND VGND VPWR VPWR _3882_ sky130_fd_sc_hd__a21o_1
XFILLER_0_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5930_ _0651_ _1588_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7600_ _3242_ _3254_ _3247_ VGND VGND VPWR VPWR _3255_ sky130_fd_sc_hd__mux2_1
X_5861_ _1367_ _1455_ _1507_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8580_ net227 _4083_ VGND VGND VPWR VPWR _4089_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5792_ _1309_ _1446_ _1317_ _1104_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__o211a_1
X_4812_ _4154_ _0499_ _0502_ _4193_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4743_ _0434_ _0437_ _4199_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__mux2_1
X_7531_ _3184_ _3185_ VGND VGND VPWR VPWR _3186_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7462_ _0614_ _3117_ VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__nand2_2
X_6413_ _2071_ _1887_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__nor2_1
XFILLER_0_71_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4674_ rf.registers\[25\]\[27\] _4167_ _4177_ rf.registers\[10\]\[27\] VGND VGND
+ VPWR VPWR _0371_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7393_ _2395_ _3049_ VGND VGND VPWR VPWR _3050_ sky130_fd_sc_hd__and2_1
X_6344_ _1865_ _1990_ _1993_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__or3_4
XFILLER_0_3_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6275_ _0646_ _1915_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_8_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8014_ _1856_ _3666_ VGND VGND VPWR VPWR _3667_ sky130_fd_sc_hd__or2_1
X_5226_ _0626_ _0884_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__and2_1
XFILLER_0_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5157_ _0811_ _0815_ _0788_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__mux2_4
XFILLER_0_98_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5088_ _0616_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8847_ clknet_4_3_0_clk _0221_ VGND VGND VPWR VPWR rf.registers\[5\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8778_ clknet_4_5_0_clk _0152_ _0051_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_93_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7729_ _3159_ _3337_ _3117_ _2437_ VGND VGND VPWR VPWR _3382_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap51 _1954_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_87_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4390_ _4195_ _4196_ _4198_ VGND VGND VPWR VPWR _4199_ sky130_fd_sc_hd__a21o_2
XFILLER_0_68_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6060_ _1597_ _1702_ _1716_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__o21ai_2
X_5011_ _0664_ _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6962_ _2618_ _2614_ VGND VGND VPWR VPWR _2619_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8701_ clknet_4_12_0_clk _0075_ VGND VGND VPWR VPWR rf.registers\[25\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_6893_ _2527_ _2528_ _2548_ _2549_ VGND VGND VPWR VPWR _2550_ sky130_fd_sc_hd__a211oi_1
X_5913_ _1550_ _1570_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8632_ _4116_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
X_5844_ _0651_ _1461_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__nand2_1
X_8563_ net165 _4072_ VGND VGND VPWR VPWR _4080_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5775_ _1303_ _1299_ _1336_ _1372_ _1433_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__a311o_1
XFILLER_0_29_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7514_ _3163_ _3166_ _3168_ VGND VGND VPWR VPWR _3169_ sky130_fd_sc_hd__mux2_1
X_4726_ _0371_ _4248_ _0372_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__mux2_1
X_8494_ _4059_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__clkbuf_1
X_7445_ net37 _3018_ VGND VGND VPWR VPWR _3101_ sky130_fd_sc_hd__or2_1
X_4657_ _0350_ _0353_ _0339_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__mux2_1
X_7376_ _3002_ _3032_ VGND VGND VPWR VPWR _3033_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_101_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4588_ _4322_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__nand2_1
X_6327_ _1981_ net105 net114 VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__and3b_1
XFILLER_0_12_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6258_ _1773_ _1823_ _1824_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__or3_1
X_6189_ net66 _0813_ _1795_ _1846_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__or4b_1
X_5209_ _0807_ _0658_ _0655_ _0866_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__a41o_1
XFILLER_0_98_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5560_ _1213_ _1218_ _1021_ _1207_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__a211o_1
X_4511_ _4210_ _4311_ VGND VGND VPWR VPWR _4320_ sky130_fd_sc_hd__and2_1
X_5491_ _1147_ _1149_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7230_ _2403_ _2886_ VGND VGND VPWR VPWR _2887_ sky130_fd_sc_hd__nor2_1
Xhold105 rf.registers\[10\]\[30\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold116 rf.registers\[15\]\[28\] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd3_1
X_4442_ _4249_ _4250_ VGND VGND VPWR VPWR _4251_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_96_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold149 rf.registers\[10\]\[4\] VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 rf.registers\[10\]\[9\] VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 rf.registers\[5\]\[21\] VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
X_4373_ rf.registers\[5\]\[2\] net265 _4170_ rf.registers\[15\]\[2\] _4181_ VGND VGND
+ VPWR VPWR _4182_ sky130_fd_sc_hd__a221o_2
XFILLER_0_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7161_ net262 _2810_ _2816_ VGND VGND VPWR VPWR _2818_ sky130_fd_sc_hd__or3b_1
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6112_ _1651_ _1762_ _1655_ _1648_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7092_ _2704_ _2741_ _2703_ VGND VGND VPWR VPWR _2749_ sky130_fd_sc_hd__a21o_1
X_6043_ _1694_ _1697_ _1698_ _1701_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__a31oi_4
X_7994_ _3645_ _3106_ VGND VGND VPWR VPWR _3647_ sky130_fd_sc_hd__and2b_1
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6945_ _2569_ _2599_ VGND VGND VPWR VPWR _2602_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_88_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6876_ _2399_ _2532_ VGND VGND VPWR VPWR _2533_ sky130_fd_sc_hd__or2_1
X_8615_ _4143_ imem.address\[0\] _4144_ _0390_ VGND VGND VPWR VPWR _4107_ sky130_fd_sc_hd__or4_4
XFILLER_0_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5827_ _0952_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__buf_4
XFILLER_0_60_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5758_ _1409_ _1413_ _1415_ _1416_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__a211o_1
X_8546_ _3995_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__inv_2
X_4709_ _0401_ _0404_ _4182_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__mux2_2
X_8477_ _4050_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7428_ _3053_ _3056_ VGND VGND VPWR VPWR _3085_ sky130_fd_sc_hd__and2_1
X_5689_ _1230_ _1347_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7359_ _2394_ _3015_ VGND VGND VPWR VPWR _3016_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_73_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6730_ _2386_ VGND VGND VPWR VPWR _2387_ sky130_fd_sc_hd__buf_2
X_4991_ _0649_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__buf_4
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6661_ _2114_ _2296_ _2316_ _2317_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_58_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_98_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6592_ net39 _0641_ net76 VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__mux2_1
X_8400_ _4009_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
X_5612_ _1269_ _1270_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5543_ _0726_ _1201_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__nand2_1
X_8331_ net131 _3970_ VGND VGND VPWR VPWR _3973_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8262_ _2276_ _3914_ _3901_ VGND VGND VPWR VPWR _3915_ sky130_fd_sc_hd__o21a_1
X_5474_ _1085_ _1089_ net69 _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__nand4_2
XFILLER_0_14_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8193_ _3709_ _3841_ VGND VGND VPWR VPWR _3846_ sky130_fd_sc_hd__or2_1
X_7213_ _2867_ _2868_ _2869_ VGND VGND VPWR VPWR _2870_ sky130_fd_sc_hd__a21oi_1
X_4425_ rf.registers\[5\]\[27\] _4149_ _4176_ rf.registers\[15\]\[27\] VGND VGND VPWR
+ VPWR _4234_ sky130_fd_sc_hd__a22o_1
X_4356_ _4164_ VGND VGND VPWR VPWR _4165_ sky130_fd_sc_hd__clkbuf_4
X_7144_ _2391_ _2799_ VGND VGND VPWR VPWR _2801_ sky130_fd_sc_hd__nor2_1
X_7075_ _2696_ _2698_ _2678_ _2679_ _2699_ VGND VGND VPWR VPWR _2732_ sky130_fd_sc_hd__a2111o_1
X_6026_ _1564_ _1563_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7977_ _3110_ net5 _3094_ VGND VGND VPWR VPWR _3630_ sky130_fd_sc_hd__or3b_1
XFILLER_0_89_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6928_ _2540_ _2552_ VGND VGND VPWR VPWR _2585_ sky130_fd_sc_hd__nand2_1
X_6859_ _2485_ _2483_ VGND VGND VPWR VPWR _2516_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout66 net11 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_2
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8529_ _3995_ VGND VGND VPWR VPWR _4070_ sky130_fd_sc_hd__buf_4
XFILLER_0_32_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_56_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload14 clknet_4_15_0_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__inv_8
XFILLER_0_23_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5190_ _0844_ _0792_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__a21boi_2
X_7900_ _3355_ _3546_ VGND VGND VPWR VPWR _3553_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7831_ _3374_ _3483_ VGND VGND VPWR VPWR _3484_ sky130_fd_sc_hd__nor2_1
X_4974_ _0623_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__buf_6
X_7762_ _3411_ _3414_ VGND VGND VPWR VPWR _3415_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_102_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6713_ _2369_ _2325_ _2328_ _2333_ _2319_ VGND VGND VPWR VPWR _2370_ sky130_fd_sc_hd__o311a_1
X_7693_ net36 _3342_ _3344_ _3345_ VGND VGND VPWR VPWR _3346_ sky130_fd_sc_hd__a22o_1
X_6644_ _0639_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__buf_4
XFILLER_0_73_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload8 clknet_4_9_0_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_61_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6575_ _2195_ _2203_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8314_ _3964_ _3960_ _3806_ VGND VGND VPWR VPWR _3965_ sky130_fd_sc_hd__and3b_1
X_5526_ _1047_ _1091_ _1092_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__o21ai_1
X_8245_ _3876_ _3875_ _3878_ _3897_ VGND VGND VPWR VPWR _3898_ sky130_fd_sc_hd__and4bb_1
X_5457_ _1114_ _0909_ _1115_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__a21oi_4
X_4408_ _4213_ _4214_ _4216_ VGND VGND VPWR VPWR _4217_ sky130_fd_sc_hd__or3_1
X_8176_ net99 _3825_ _3827_ _3828_ _3771_ VGND VGND VPWR VPWR _3829_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_70_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5388_ _0643_ _1046_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__and2_1
X_4339_ _4147_ VGND VGND VPWR VPWR _4148_ sky130_fd_sc_hd__buf_2
X_7127_ net64 _2783_ _2779_ VGND VGND VPWR VPWR _2784_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7058_ _2672_ _2714_ _2702_ VGND VGND VPWR VPWR _2715_ sky130_fd_sc_hd__mux2_1
X_6009_ _1583_ _1667_ _1582_ _1578_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_69_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4690_ _4158_ _0334_ _0386_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6360_ _2016_ _2018_ _0638_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5311_ _0906_ _0959_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8030_ _3681_ _3682_ VGND VGND VPWR VPWR _3683_ sky130_fd_sc_hd__xor2_1
X_6291_ _1816_ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5242_ _0657_ _0896_ _0900_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__a21o_1
X_5173_ _0762_ _0764_ _0767_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__or3_1
Xinput1 control VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_67_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8863_ clknet_4_1_0_clk _0006_ VGND VGND VPWR VPWR display.refresh_counter\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7814_ _3464_ _3466_ VGND VGND VPWR VPWR _3467_ sky130_fd_sc_hd__or2_1
X_8794_ clknet_4_9_0_clk _0168_ VGND VGND VPWR VPWR rf.registers\[10\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_4957_ _0614_ _0616_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__nor2_1
X_7745_ _3391_ _3397_ VGND VGND VPWR VPWR _3398_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4888_ _4315_ _4314_ _0289_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__nand3_1
X_7676_ net110 _0813_ VGND VGND VPWR VPWR _3331_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6627_ _2284_ _2279_ _2277_ VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6558_ _2195_ _2203_ _2215_ _2216_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6489_ _0630_ _2147_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__xnor2_1
X_5509_ _1167_ _0634_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__nand2_1
X_8228_ _3680_ _3811_ _3880_ VGND VGND VPWR VPWR _3881_ sky130_fd_sc_hd__or3b_1
X_8159_ net78 _3691_ net95 _3758_ _3731_ VGND VGND VPWR VPWR _3812_ sky130_fd_sc_hd__a311o_1
XFILLER_0_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_29_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5860_ _1360_ _1361_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_36_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4811_ _0500_ _0501_ _0445_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5791_ _1445_ _1119_ _1449_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_38_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4742_ _0435_ _0436_ _0344_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7530_ net62 _3183_ VGND VGND VPWR VPWR _3185_ sky130_fd_sc_hd__and2_1
XFILLER_0_83_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4673_ _0363_ _0368_ _0369_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__mux2_1
X_7461_ net110 _0813_ VGND VGND VPWR VPWR _3117_ sky130_fd_sc_hd__nor2_1
X_6412_ _1865_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__buf_6
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7392_ _3027_ _3031_ _3048_ _3022_ VGND VGND VPWR VPWR _3049_ sky130_fd_sc_hd__o22a_1
XFILLER_0_24_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6343_ net113 _1985_ _1986_ _1970_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__a211o_1
XFILLER_0_12_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6274_ _0638_ _1912_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_47_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8013_ _2296_ _2273_ _2278_ VGND VGND VPWR VPWR _3666_ sky130_fd_sc_hd__a21oi_1
X_5225_ _0804_ _0883_ _0856_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__mux2_1
X_5156_ _0812_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__or2b_1
XFILLER_0_98_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5087_ _0744_ _0745_ _0735_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__mux2_2
XFILLER_0_78_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8846_ clknet_4_3_0_clk _0220_ VGND VGND VPWR VPWR rf.registers\[5\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8777_ clknet_4_5_0_clk _0151_ _0050_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dfrtp_2
X_5989_ _1647_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__inv_2
XFILLER_0_62_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7728_ _0694_ _3341_ _3380_ VGND VGND VPWR VPWR _3381_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_62_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7659_ _3306_ _3313_ _3308_ VGND VGND VPWR VPWR _3314_ sky130_fd_sc_hd__o21a_1
XFILLER_0_62_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_74_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap52 _2903_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_87_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_83_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5010_ _0666_ _0665_ _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8700_ clknet_4_12_0_clk _0074_ VGND VGND VPWR VPWR rf.registers\[25\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_6961_ _2573_ _2574_ VGND VGND VPWR VPWR _2618_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6892_ _2541_ _2524_ _2542_ VGND VGND VPWR VPWR _2549_ sky130_fd_sc_hd__a21oi_1
X_5912_ _1551_ _1546_ _1547_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__nand3_1
XFILLER_0_48_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8631_ net191 _4108_ VGND VGND VPWR VPWR _4116_ sky130_fd_sc_hd__and2_1
X_5843_ _1478_ _1462_ _1501_ _1483_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_91_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8562_ _4079_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5774_ _1303_ _1336_ _1299_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__a21oi_1
X_7513_ _3167_ VGND VGND VPWR VPWR _3168_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4725_ _0379_ _4178_ _0372_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8493_ net232 _4056_ VGND VGND VPWR VPWR _4059_ sky130_fd_sc_hd__and2_1
X_7444_ _3098_ _3099_ VGND VGND VPWR VPWR _3100_ sky130_fd_sc_hd__or2_1
X_4656_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__inv_2
X_7375_ _3005_ _3013_ _3031_ VGND VGND VPWR VPWR _3032_ sky130_fd_sc_hd__or3b_1
X_4587_ _4319_ _4321_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__or2_1
XFILLER_0_101_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6326_ _1984_ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__inv_2
XFILLER_0_12_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6257_ _0646_ _1915_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__and2_1
X_6188_ _1846_ _1823_ _1824_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__or3_1
X_5208_ _0618_ _0809_ _0806_ _0808_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__o211a_1
X_5139_ _0657_ _0797_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8829_ clknet_4_8_0_clk _0203_ VGND VGND VPWR VPWR rf.registers\[5\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4510_ rf.registers\[25\]\[11\] _4165_ _4173_ rf.registers\[10\]\[11\] VGND VGND
+ VPWR VPWR _4319_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5490_ _1061_ _1148_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold106 rf.registers\[15\]\[8\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
Xhold117 rf.registers\[5\]\[13\] VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4441_ _4179_ _4236_ _4237_ VGND VGND VPWR VPWR _4250_ sky130_fd_sc_hd__a21oi_1
Xhold128 rf.registers\[5\]\[17\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7160_ _2791_ _2794_ _2816_ VGND VGND VPWR VPWR _2817_ sky130_fd_sc_hd__and3_1
Xhold139 rf.registers\[25\]\[28\] VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
X_4372_ _4180_ _4152_ VGND VGND VPWR VPWR _4181_ sky130_fd_sc_hd__and2_1
X_6111_ _1651_ _1762_ _1655_ _1648_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__or4bb_1
X_7091_ _2725_ _2729_ _2745_ VGND VGND VPWR VPWR _2748_ sky130_fd_sc_hd__or3_1
X_6042_ _1588_ _1699_ _1700_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__and3_1
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7993_ _3106_ _3645_ VGND VGND VPWR VPWR _3646_ sky130_fd_sc_hd__and2b_1
X_6944_ _2594_ _2600_ VGND VGND VPWR VPWR _2601_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_105_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6875_ _2496_ _2524_ _2530_ _2531_ VGND VGND VPWR VPWR _2532_ sky130_fd_sc_hd__a2bb2o_1
X_8614_ _4106_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5826_ _1405_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__inv_2
XFILLER_0_91_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8545_ _3995_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__inv_2
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5757_ _1121_ _1412_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4708_ _0402_ _0403_ _4186_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__mux2_1
X_8476_ net152 _4045_ VGND VGND VPWR VPWR _4050_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7427_ _3055_ VGND VGND VPWR VPWR _3084_ sky130_fd_sc_hd__inv_2
XFILLER_0_4_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5688_ _1344_ _1346_ _1245_ _1237_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__a31o_1
XFILLER_0_32_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4639_ _4306_ _4304_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_73_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7358_ _3014_ _2995_ _2984_ _3003_ VGND VGND VPWR VPWR _3015_ sky130_fd_sc_hd__o2bb2a_1
X_6309_ _1949_ _1964_ _1966_ _1967_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__a31oi_4
X_7289_ _2942_ _2945_ net66 _2939_ VGND VGND VPWR VPWR _2946_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_591 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4990_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__buf_4
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6660_ _2115_ _2313_ _2315_ _2283_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_98_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6591_ _2233_ _2109_ _2249_ VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__a21o_1
X_5611_ _1164_ _1170_ _1172_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_5_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5542_ _0907_ net75 _1134_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__nor3_2
X_8330_ display.refresh_counter\[3\] _3970_ VGND VGND VPWR VPWR _3972_ sky130_fd_sc_hd__and2_1
X_8261_ _3709_ _3906_ VGND VGND VPWR VPWR _3914_ sky130_fd_sc_hd__and2_1
X_5473_ _1131_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__inv_2
X_8192_ _1856_ _1795_ _3841_ _3844_ _1689_ VGND VGND VPWR VPWR _3845_ sky130_fd_sc_hd__a32o_1
X_4424_ _4226_ _4230_ _4231_ _4232_ VGND VGND VPWR VPWR _4233_ sky130_fd_sc_hd__or4_1
X_7212_ _2861_ _2854_ VGND VGND VPWR VPWR _2869_ sky130_fd_sc_hd__and2_1
X_4355_ _4160_ _4163_ VGND VGND VPWR VPWR _4164_ sky130_fd_sc_hd__nand2_4
X_7143_ _2764_ _2767_ VGND VGND VPWR VPWR _2800_ sky130_fd_sc_hd__nor2_1
X_7074_ _2675_ _2677_ _2681_ VGND VGND VPWR VPWR _2731_ sky130_fd_sc_hd__a21o_1
XFILLER_0_39_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6025_ _1021_ _1683_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__xor2_1
XFILLER_0_96_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7976_ _3335_ _3628_ VGND VGND VPWR VPWR _3629_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6927_ _2400_ _2583_ VGND VGND VPWR VPWR _2584_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6858_ _2501_ _2508_ _2513_ _2514_ VGND VGND VPWR VPWR _2515_ sky130_fd_sc_hd__o31ai_4
Xfanout67 net41 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5809_ _1369_ _1370_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8528_ _4069_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__inv_2
X_6789_ _0494_ _2397_ VGND VGND VPWR VPWR _2446_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8459_ net211 _4034_ VGND VGND VPWR VPWR _4041_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7830_ _3377_ _3473_ _3476_ _3482_ VGND VGND VPWR VPWR _3483_ sky130_fd_sc_hd__a31o_1
X_4973_ net39 VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__inv_2
X_7761_ _0494_ _3413_ _3333_ VGND VGND VPWR VPWR _3414_ sky130_fd_sc_hd__mux2_1
X_6712_ net9 _2318_ VGND VGND VPWR VPWR _2369_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7692_ _3329_ _3314_ _3342_ VGND VGND VPWR VPWR _3345_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6643_ _2230_ _2300_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload9 clknet_4_10_0_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6574_ _2157_ _2219_ _2232_ VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__a21o_4
XFILLER_0_73_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8313_ net85 _3956_ VGND VGND VPWR VPWR _3964_ sky130_fd_sc_hd__or2_1
X_5525_ _1146_ _1181_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__a21oi_2
X_8244_ _3888_ _3889_ _3895_ _3896_ VGND VGND VPWR VPWR _3897_ sky130_fd_sc_hd__and4b_1
XFILLER_0_74_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5456_ _1005_ _0684_ _0643_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__a21o_1
X_4407_ _4215_ rf.registers\[15\]\[14\] _4173_ VGND VGND VPWR VPWR _4216_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8175_ _3780_ _3787_ _3825_ VGND VGND VPWR VPWR _3828_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_70_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5387_ _0995_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__xor2_2
X_4338_ net60 VGND VGND VPWR VPWR _4147_ sky130_fd_sc_hd__buf_2
X_7126_ _2753_ _2782_ VGND VGND VPWR VPWR _2783_ sky130_fd_sc_hd__or2_1
X_7057_ _2711_ _2713_ VGND VGND VPWR VPWR _2714_ sky130_fd_sc_hd__xnor2_1
X_6008_ _1663_ _1666_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7959_ _3346_ _3611_ _3605_ VGND VGND VPWR VPWR _3612_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_25_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6290_ _1941_ _1931_ _1945_ _1948_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__a211o_4
X_5310_ _0634_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5241_ _0830_ net81 _0898_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a31o_1
X_5172_ _0798_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_67_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8862_ clknet_4_0_0_clk _0005_ VGND VGND VPWR VPWR display.refresh_counter\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_8793_ clknet_4_12_0_clk _0167_ VGND VGND VPWR VPWR rf.registers\[10\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7813_ net20 _3465_ _3334_ VGND VGND VPWR VPWR _3466_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7744_ _3333_ _3125_ _3387_ _3390_ VGND VGND VPWR VPWR _3397_ sky130_fd_sc_hd__o22ai_1
X_4956_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7675_ _3120_ _3326_ _3329_ VGND VGND VPWR VPWR _3330_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4887_ net15 _0527_ _0566_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6626_ _2283_ _2255_ _2259_ _2172_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__a211o_1
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6557_ _2193_ _2202_ _2201_ VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5508_ net64 VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__inv_2
X_6488_ _2131_ _2111_ _2145_ _2146_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__o31a_1
XFILLER_0_30_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8227_ _3690_ _3879_ _3685_ VGND VGND VPWR VPWR _3880_ sky130_fd_sc_hd__o21ba_1
X_5439_ _0691_ _1097_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__or2_1
X_8158_ _3663_ _3782_ _3785_ VGND VGND VPWR VPWR _3811_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_100_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7109_ _2744_ _2741_ _2733_ VGND VGND VPWR VPWR _2766_ sky130_fd_sc_hd__a21oi_1
X_8089_ _2345_ _2347_ VGND VGND VPWR VPWR _3742_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4810_ _0383_ _0443_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__and2_1
X_5790_ _1052_ _1448_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__nor2_1
X_4741_ _0366_ _0336_ _0339_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7460_ _3113_ _3114_ _3115_ VGND VGND VPWR VPWR _3116_ sky130_fd_sc_hd__nand3b_4
X_4672_ _4182_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_16_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6411_ _2067_ _2066_ _2069_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__a21o_4
X_7391_ _3017_ _3021_ _3031_ VGND VGND VPWR VPWR _3048_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6342_ _1486_ _1997_ _1998_ _1999_ _2000_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__o32a_1
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6273_ _1888_ _1894_ _1901_ _1905_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__and4_1
X_8012_ _2284_ _2279_ VGND VGND VPWR VPWR _3665_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5224_ _0818_ _0882_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__xnor2_1
X_5155_ _0534_ _0813_ _0622_ _0811_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__or4_1
X_5086_ _0706_ _0711_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__xor2_1
XFILLER_0_47_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8845_ clknet_4_3_0_clk _0219_ VGND VGND VPWR VPWR rf.registers\[5\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8776_ clknet_4_5_0_clk _0150_ _0049_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dfrtp_4
X_5988_ _1639_ _1638_ _1385_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__and3_1
X_4939_ _0259_ _0605_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__nor2_1
X_7727_ _3347_ _2458_ _3170_ _3337_ _3333_ VGND VGND VPWR VPWR _3380_ sky130_fd_sc_hd__o221a_1
X_7658_ _3299_ _3312_ VGND VGND VPWR VPWR _3313_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6609_ _2262_ _2263_ _0639_ _2264_ VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__o211a_1
XFILLER_0_62_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7589_ net15 _3240_ _3233_ VGND VGND VPWR VPWR _3244_ sky130_fd_sc_hd__o21a_1
XFILLER_0_30_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap53 _2883_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_87_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6960_ _2594_ _2600_ _2616_ _2602_ VGND VGND VPWR VPWR _2617_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_49_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5911_ net74 VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__buf_6
XFILLER_0_76_615 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6891_ _2541_ _2542_ _2524_ VGND VGND VPWR VPWR _2548_ sky130_fd_sc_hd__and3_1
X_8630_ _4115_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
X_5842_ _1491_ _1498_ _1499_ _1500_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_91_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8561_ net153 _4072_ VGND VGND VPWR VPWR _4079_ sky130_fd_sc_hd__and2_1
X_5773_ _1012_ _1431_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4724_ _0417_ _0419_ _0376_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__mux2_1
X_7512_ _3158_ _3154_ _3160_ _3153_ VGND VGND VPWR VPWR _3167_ sky130_fd_sc_hd__a22o_1
XFILLER_0_83_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8492_ _4058_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__clkbuf_1
X_7443_ _3069_ _3093_ _3071_ VGND VGND VPWR VPWR _3099_ sky130_fd_sc_hd__a21oi_1
X_4655_ _0346_ _0351_ _0256_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_2_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7374_ _3016_ _3028_ _3030_ VGND VGND VPWR VPWR _3031_ sky130_fd_sc_hd__o21ai_4
X_4586_ _4329_ _0280_ _0282_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6325_ _1845_ _1983_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6256_ _1779_ _1914_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__xnor2_2
X_6187_ _1706_ _1707_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__nor2_1
X_5207_ _0753_ _0789_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__xnor2_1
X_5138_ _0764_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5069_ _0690_ _0727_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__or2_1
XFILLER_0_94_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8828_ clknet_4_9_0_clk _0202_ VGND VGND VPWR VPWR rf.registers\[5\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_8759_ clknet_4_13_0_clk _0133_ _0032_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold107 rf.registers\[15\]\[26\] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
X_4440_ _4179_ _4236_ _4237_ VGND VGND VPWR VPWR _4249_ sky130_fd_sc_hd__and3_1
Xhold129 rf.registers\[10\]\[19\] VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
Xhold118 rf.registers\[15\]\[27\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlygate4sd3_1
X_4371_ net1 imem.address\[0\] VGND VGND VPWR VPWR _4180_ sky130_fd_sc_hd__and2_1
X_6110_ _1768_ _1766_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7090_ _2743_ _2746_ VGND VGND VPWR VPWR _2747_ sky130_fd_sc_hd__nand2_1
X_6041_ _1693_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__buf_4
X_7992_ _3105_ _3116_ VGND VGND VPWR VPWR _3645_ sky130_fd_sc_hd__and2_1
X_6943_ net20 _2400_ _2596_ _2598_ _2599_ VGND VGND VPWR VPWR _2600_ sky130_fd_sc_hd__a221o_1
XFILLER_0_76_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6874_ _2497_ _2515_ VGND VGND VPWR VPWR _2531_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5825_ _1121_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__buf_6
XFILLER_0_48_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8613_ net212 _4071_ VGND VGND VPWR VPWR _4106_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8544_ _3995_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__inv_2
X_5756_ _1275_ _1414_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__xnor2_1
X_4707_ _0372_ _0255_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__and2_1
X_8475_ _4049_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
X_5687_ _1265_ _1277_ _1345_ _1284_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__a211o_1
X_7426_ _2395_ _3082_ VGND VGND VPWR VPWR _3083_ sky130_fd_sc_hd__and2_1
X_4638_ net59 VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4569_ _0247_ _0264_ _0265_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__o21ai_1
X_7357_ _2985_ _2994_ _2999_ VGND VGND VPWR VPWR _3014_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_69_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6308_ _1834_ _1964_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__nor2_1
X_7288_ net66 _2917_ VGND VGND VPWR VPWR _2945_ sky130_fd_sc_hd__nor2_1
X_6239_ net90 _1837_ _1897_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6590_ _2157_ _2241_ _2244_ _2248_ VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__a211o_4
X_5610_ _1267_ _1268_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5541_ _1027_ _1134_ _1005_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__o21ai_1
X_8260_ _3902_ _3907_ _3911_ _3912_ VGND VGND VPWR VPWR _3913_ sky130_fd_sc_hd__and4_1
XFILLER_0_26_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5472_ _1126_ _1129_ _1130_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__and3_1
X_7211_ _1406_ _2392_ _2854_ VGND VGND VPWR VPWR _2868_ sky130_fd_sc_hd__o21ai_1
X_8191_ net99 _3812_ _3842_ _3843_ VGND VGND VPWR VPWR _3844_ sky130_fd_sc_hd__a31oi_1
X_4423_ rf.registers\[5\]\[24\] _4149_ _4176_ rf.registers\[15\]\[24\] VGND VGND VPWR
+ VPWR _4232_ sky130_fd_sc_hd__a22o_1
X_4354_ net60 _4154_ _4162_ VGND VGND VPWR VPWR _4163_ sky130_fd_sc_hd__o21ai_4
X_7142_ _2770_ _2771_ VGND VGND VPWR VPWR _2799_ sky130_fd_sc_hd__and2_1
X_7073_ _2717_ _2720_ VGND VGND VPWR VPWR _2730_ sky130_fd_sc_hd__xnor2_1
X_6024_ _1563_ _1565_ _1570_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__and3b_1
XFILLER_0_96_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7975_ _3622_ _3625_ _3627_ VGND VGND VPWR VPWR _3628_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_68_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6926_ _2580_ _2566_ _2581_ _2582_ VGND VGND VPWR VPWR _2583_ sky130_fd_sc_hd__o31ai_2
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6857_ _2399_ _2499_ _2500_ VGND VGND VPWR VPWR _2514_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6788_ _2442_ _2444_ _2437_ VGND VGND VPWR VPWR _2445_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5808_ _0635_ _1466_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__xnor2_1
X_8527_ _4069_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__inv_2
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5739_ _0651_ _1349_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8458_ _4040_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8389_ _4003_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
X_7409_ _3040_ _3041_ _3059_ VGND VGND VPWR VPWR _3066_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_56_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4972_ net39 _0630_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__nor2_1
X_7760_ _3412_ VGND VGND VPWR VPWR _3413_ sky130_fd_sc_hd__inv_2
X_6711_ _2354_ _2365_ _2367_ VGND VGND VPWR VPWR _2368_ sky130_fd_sc_hd__a21boi_1
X_7691_ _3119_ _3059_ _3343_ _3329_ VGND VGND VPWR VPWR _3344_ sky130_fd_sc_hd__a211o_1
XFILLER_0_19_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_102_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6642_ _2296_ _2298_ _2299_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8312_ _3963_ VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
X_6573_ _2220_ _2222_ _2129_ _2229_ _2231_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__a221o_1
XFILLER_0_42_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5524_ _0628_ _1182_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8243_ _2302_ _3893_ VGND VGND VPWR VPWR _3896_ sky130_fd_sc_hd__or2_1
X_5455_ _1113_ _1108_ _1104_ _0785_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__a31o_4
X_8174_ _3736_ _3824_ _3741_ VGND VGND VPWR VPWR _3827_ sky130_fd_sc_hd__o21ai_1
X_4406_ rf.registers\[5\]\[14\] _4148_ VGND VGND VPWR VPWR _4215_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5386_ _1005_ _0992_ _1031_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__or3_1
X_7125_ _1167_ _2402_ VGND VGND VPWR VPWR _2782_ sky130_fd_sc_hd__nor2_1
X_4337_ imem.address\[4\] _4143_ _4144_ _4145_ VGND VGND VPWR VPWR _4146_ sky130_fd_sc_hd__nor4_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7056_ _2712_ _2688_ VGND VGND VPWR VPWR _2713_ sky130_fd_sc_hd__or2_1
X_6007_ _1664_ _1665_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__nor2_1
X_7958_ _3609_ _3610_ _3607_ VGND VGND VPWR VPWR _3611_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_25_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7889_ _3355_ _3541_ VGND VGND VPWR VPWR _3542_ sky130_fd_sc_hd__nor2_1
X_6909_ _2533_ _2540_ _2552_ _2555_ VGND VGND VPWR VPWR _2566_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_92_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5240_ net88 _0854_ _0797_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__o21a_1
X_5171_ _0825_ _0799_ _0827_ _0829_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8861_ clknet_4_1_0_clk _0004_ VGND VGND VPWR VPWR display.refresh_counter\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_8792_ clknet_4_12_0_clk _0166_ VGND VGND VPWR VPWR rf.registers\[10\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_7812_ _3338_ _3191_ _2558_ _3118_ VGND VGND VPWR VPWR _3465_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_93_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4955_ display.refresh_counter\[19\] display.refresh_counter\[17\] VGND VGND VPWR
+ VPWR _0615_ sky130_fd_sc_hd__nand2_1
X_7743_ _3394_ _3395_ VGND VGND VPWR VPWR _3396_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4886_ _0550_ _0293_ _0565_ _0406_ _0469_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__a32o_1
X_7674_ _3328_ VGND VGND VPWR VPWR _3329_ sky130_fd_sc_hd__clkbuf_4
X_6625_ net76 VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__buf_6
XFILLER_0_104_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6556_ _2207_ _2213_ _2214_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_30_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5507_ net17 _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__xnor2_1
X_8226_ net108 _3705_ VGND VGND VPWR VPWR _3879_ sky130_fd_sc_hd__and2b_1
X_6487_ net87 _2095_ _2049_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__or3b_1
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5438_ _1012_ _1034_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8157_ _3801_ _3809_ _3802_ VGND VGND VPWR VPWR _3810_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_10_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5369_ _0722_ _1020_ _1027_ _0906_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__o22ai_1
X_8088_ net9 _3740_ VGND VGND VPWR VPWR _3741_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7108_ _2733_ _2744_ _2741_ VGND VGND VPWR VPWR _2765_ sky130_fd_sc_hd__and3_1
X_7039_ _2389_ _2669_ _2673_ _2691_ _2695_ VGND VGND VPWR VPWR _2696_ sky130_fd_sc_hd__a221o_2
XFILLER_0_69_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4740_ _0360_ _0364_ _0339_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4671_ _0364_ _0366_ _0367_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7390_ _3045_ _3046_ VGND VGND VPWR VPWR _3047_ sky130_fd_sc_hd__xnor2_1
X_6410_ _1980_ _2068_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6341_ net40 _0630_ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6272_ _1875_ _1880_ _1906_ _1930_ _1925_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_11_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8011_ _2254_ _2261_ VGND VGND VPWR VPWR _3664_ sky130_fd_sc_hd__nor2_1
X_5223_ _0810_ _0817_ _0819_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__a21oi_1
X_5154_ net91 VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__buf_4
XFILLER_0_47_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5085_ _0705_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8844_ clknet_4_1_0_clk _0218_ VGND VGND VPWR VPWR rf.registers\[5\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8775_ clknet_4_4_0_clk _0149_ _0048_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dfrtp_4
X_5987_ _0645_ _1640_ _1643_ _1645_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__a211oi_1
X_4938_ _0256_ _0258_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__and2_1
X_7726_ _0534_ _3378_ _3334_ VGND VGND VPWR VPWR _3379_ sky130_fd_sc_hd__mux2_1
X_7657_ _0587_ _3304_ VGND VGND VPWR VPWR _3312_ sky130_fd_sc_hd__and2b_1
XFILLER_0_74_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4869_ _4297_ _4298_ _0299_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_105_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6608_ _0639_ _2265_ VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7588_ net15 _3233_ VGND VGND VPWR VPWR _3243_ sky130_fd_sc_hd__nor2_1
X_6539_ _2003_ _2191_ VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8209_ _3861_ _3722_ _3855_ _3858_ VGND VGND VPWR VPWR _3862_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_7_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5910_ _1568_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__buf_6
XFILLER_0_76_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6890_ _2545_ _2546_ _2399_ VGND VGND VPWR VPWR _2547_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5841_ _1484_ _1490_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__or2_1
X_8560_ _4078_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5772_ _1302_ _1430_ _1335_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__mux2_1
X_8491_ net197 _4056_ VGND VGND VPWR VPWR _4058_ sky130_fd_sc_hd__and2_1
X_4723_ _0372_ _4272_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__o21ai_1
X_7511_ _3163_ _3165_ VGND VGND VPWR VPWR _3166_ sky130_fd_sc_hd__nor2_1
X_7442_ _3071_ _3069_ _3093_ VGND VGND VPWR VPWR _3098_ sky130_fd_sc_hd__and3_1
XFILLER_0_56_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4654_ _0252_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__inv_2
X_4585_ _4325_ _0281_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__and2_1
X_7373_ _2981_ _3003_ _3029_ _2996_ VGND VGND VPWR VPWR _3030_ sky130_fd_sc_hd__o22a_1
X_6324_ _1859_ _1982_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6255_ _1823_ _1824_ _1908_ _1907_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__o211a_1
XFILLER_0_58_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5206_ _0864_ _0800_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__xnor2_2
X_6186_ _0620_ _1840_ _1841_ _1842_ _1844_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__a32o_1
X_5137_ _0795_ _0766_ _0789_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5068_ _0726_ _0689_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8827_ clknet_4_8_0_clk _0201_ VGND VGND VPWR VPWR rf.registers\[5\]\[11\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8758_ clknet_4_15_0_clk _0132_ _0031_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_66_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7709_ net3 _3248_ _3360_ _3361_ VGND VGND VPWR VPWR _3362_ sky130_fd_sc_hd__o22a_1
X_8689_ clknet_4_14_0_clk _0063_ VGND VGND VPWR VPWR rf.registers\[25\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold108 rf.registers\[15\]\[15\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
X_4370_ _4163_ VGND VGND VPWR VPWR _4179_ sky130_fd_sc_hd__buf_2
Xhold119 rf.registers\[5\]\[22\] VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_95_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6040_ _1692_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__buf_6
XFILLER_0_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7991_ _3641_ _3643_ VGND VGND VPWR VPWR _3644_ sky130_fd_sc_hd__nor2_1
X_6942_ _2589_ _2592_ _2564_ VGND VGND VPWR VPWR _2599_ sky130_fd_sc_hd__a21boi_4
X_6873_ _2497_ _2515_ _2517_ VGND VGND VPWR VPWR _2530_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_105_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8612_ _4105_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
X_5824_ _1439_ _1482_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5755_ _1256_ _1372_ _1386_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__a21o_1
X_8543_ _3995_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__inv_2
XFILLER_0_97_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4706_ _0252_ _0248_ _0346_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__mux2_1
X_8474_ net171 _4045_ VGND VGND VPWR VPWR _4049_ sky130_fd_sc_hd__and2_1
X_5686_ _1120_ _1278_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7425_ _3081_ _3053_ _3049_ _3059_ VGND VGND VPWR VPWR _3082_ sky130_fd_sc_hd__o2bb2a_1
X_4637_ _0327_ _0333_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4568_ _0237_ _0240_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__xnor2_1
X_7356_ _3007_ _3011_ _3012_ VGND VGND VPWR VPWR _3013_ sky130_fd_sc_hd__and3_1
XFILLER_0_69_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4499_ _4294_ _4307_ VGND VGND VPWR VPWR _4308_ sky130_fd_sc_hd__nand2_1
X_6307_ _1947_ _1965_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__or2_1
X_7287_ _2941_ _2943_ VGND VGND VPWR VPWR _2944_ sky130_fd_sc_hd__or2_1
X_6238_ _1753_ _1896_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__xnor2_1
X_6169_ _1799_ _1827_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclone20 _2089_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_23_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5540_ _1196_ _1125_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5471_ _1077_ _1085_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4422_ rf.registers\[5\]\[25\] _4149_ _4176_ rf.registers\[15\]\[25\] VGND VGND VPWR
+ VPWR _4231_ sky130_fd_sc_hd__a22o_1
X_7210_ _2822_ _2816_ _2821_ _2823_ VGND VGND VPWR VPWR _2867_ sky130_fd_sc_hd__a31o_1
X_8190_ _3756_ _3811_ VGND VGND VPWR VPWR _3843_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4353_ _4161_ VGND VGND VPWR VPWR _4162_ sky130_fd_sc_hd__clkbuf_2
X_7141_ _2391_ _2797_ VGND VGND VPWR VPWR _2798_ sky130_fd_sc_hd__nand2_1
X_7072_ _2728_ _2390_ VGND VGND VPWR VPWR _2729_ sky130_fd_sc_hd__nor2_1
X_6023_ _1678_ _1663_ _1681_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__a21oi_2
X_7974_ _3621_ _3626_ VGND VGND VPWR VPWR _3627_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6925_ _2545_ _2546_ _2566_ VGND VGND VPWR VPWR _2582_ sky130_fd_sc_hd__nand3_1
XFILLER_0_49_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6856_ _2509_ _2510_ _2511_ _2512_ VGND VGND VPWR VPWR _2513_ sky130_fd_sc_hd__or4_2
XFILLER_0_36_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6787_ _0494_ _2397_ _2443_ _2438_ VGND VGND VPWR VPWR _2444_ sky130_fd_sc_hd__a31oi_1
X_5807_ _1414_ _1465_ _1455_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__mux2_4
X_8526_ _4069_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__inv_2
X_5738_ _0635_ _1353_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_20_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8457_ net203 _4034_ VGND VGND VPWR VPWR _4040_ sky130_fd_sc_hd__and2_1
X_5669_ _1292_ _1293_ _1295_ _1327_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__or4_4
XFILLER_0_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7408_ _2395_ _3064_ VGND VGND VPWR VPWR _3065_ sky130_fd_sc_hd__xnor2_1
X_8388_ net223 _0594_ _3997_ VGND VGND VPWR VPWR _4003_ sky130_fd_sc_hd__mux2_1
X_7339_ _2394_ _2981_ _2995_ VGND VGND VPWR VPWR _2996_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4971_ _0629_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__buf_4
X_6710_ _2366_ _2345_ VGND VGND VPWR VPWR _2367_ sky130_fd_sc_hd__and2b_1
XFILLER_0_86_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7690_ _3119_ _2111_ VGND VGND VPWR VPWR _3343_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_102_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6641_ _2175_ _2283_ _2297_ _2171_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8311_ net79 _3961_ _3962_ VGND VGND VPWR VPWR _3963_ sky130_fd_sc_hd__and3_1
X_6572_ _2230_ _2117_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5523_ _1046_ _1133_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__xor2_2
X_8242_ net99 _3891_ _3893_ _2302_ _3894_ VGND VGND VPWR VPWR _3895_ sky130_fd_sc_hd__a221oi_1
X_5454_ _0930_ _1097_ _1112_ _1110_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__or4_4
X_8173_ _3771_ _3780_ net92 _3825_ VGND VGND VPWR VPWR _3826_ sky130_fd_sc_hd__and4b_1
X_4405_ rf.registers\[5\]\[15\] _4148_ _4173_ rf.registers\[15\]\[15\] VGND VGND VPWR
+ VPWR _4214_ sky130_fd_sc_hd__a22o_1
X_5385_ _0634_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__and2_1
X_4336_ net1 imem.address\[0\] VGND VGND VPWR VPWR _4145_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_70_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7124_ _2778_ _2780_ VGND VGND VPWR VPWR _2781_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7055_ _2674_ net263 VGND VGND VPWR VPWR _2712_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6006_ _1582_ _1581_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__and2_1
X_7957_ _3346_ _3605_ VGND VGND VPWR VPWR _3610_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7888_ _3359_ _3533_ _3536_ _3540_ VGND VGND VPWR VPWR _3541_ sky130_fd_sc_hd__a31o_1
X_6908_ _2404_ _2521_ VGND VGND VPWR VPWR _2565_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6839_ _2470_ _2495_ _2489_ VGND VGND VPWR VPWR _2496_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8509_ net201 _4033_ VGND VGND VPWR VPWR _4067_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5170_ _0798_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8860_ clknet_4_1_0_clk _0003_ VGND VGND VPWR VPWR display.refresh_counter\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_8791_ clknet_4_15_0_clk _0165_ VGND VGND VPWR VPWR rf.registers\[10\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_7811_ _3379_ _3456_ _3458_ _3463_ VGND VGND VPWR VPWR _3464_ sky130_fd_sc_hd__a31o_1
XFILLER_0_59_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4954_ display.refresh_counter\[18\] VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__buf_4
X_7742_ _3337_ _3128_ _0468_ _3341_ VGND VGND VPWR VPWR _3395_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_52_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4885_ _0292_ _4314_ _0290_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__nand3_1
X_7673_ _3327_ _0659_ VGND VGND VPWR VPWR _3328_ sky130_fd_sc_hd__and2_2
X_6624_ _0639_ _2265_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6555_ _2204_ _2206_ _2124_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5506_ _0627_ _1114_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8225_ _2230_ _3860_ _3877_ VGND VGND VPWR VPWR _3878_ sky130_fd_sc_hd__o21a_1
X_6486_ _2050_ _2026_ _2029_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__and3_1
XFILLER_0_42_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5437_ _1038_ _1095_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__nand2_1
X_8156_ _3799_ _3805_ VGND VGND VPWR VPWR _3809_ sky130_fd_sc_hd__or2_1
X_5368_ _0925_ _1026_ net75 VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__mux2_1
X_8087_ _3660_ _3738_ _3739_ _2324_ VGND VGND VPWR VPWR _3740_ sky130_fd_sc_hd__o22a_1
XFILLER_0_10_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5299_ _0957_ _0877_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__xnor2_1
X_7107_ _2751_ _2754_ _2749_ _2748_ VGND VGND VPWR VPWR _2764_ sky130_fd_sc_hd__o211a_1
X_7038_ _2401_ _2694_ VGND VGND VPWR VPWR _2695_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_2_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_38_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4670_ _4186_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_71_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6340_ net67 _0620_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6271_ _0646_ _1915_ _1929_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__o21bai_2
X_8010_ net9 _3662_ VGND VGND VPWR VPWR _3663_ sky130_fd_sc_hd__or2_2
X_5222_ _0800_ _0864_ _0870_ _0649_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__a22oi_1
X_5153_ _0618_ _0811_ _0752_ _0754_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_16_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5084_ _0742_ _0656_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_78_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8843_ clknet_4_0_0_clk _0217_ VGND VGND VPWR VPWR rf.registers\[5\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8774_ clknet_4_4_0_clk _0148_ _0047_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dfrtp_4
X_5986_ _1466_ _1644_ net74 VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__mux2_2
X_4937_ net32 _4160_ _0390_ _0604_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__a31o_1
X_7725_ _3338_ _3183_ _2524_ _3118_ VGND VGND VPWR VPWR _3378_ sky130_fd_sc_hd__a2bb2o_1
X_7656_ net36 _3305_ VGND VGND VPWR VPWR _3311_ sky130_fd_sc_hd__nand2_1
X_4868_ _4297_ _4298_ _0299_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__or3_1
XFILLER_0_19_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6607_ _2262_ _2263_ _2264_ VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__o21a_1
XFILLER_0_6_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4799_ _0488_ _0490_ _4199_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__mux2_1
X_7587_ net65 _3241_ VGND VGND VPWR VPWR _3242_ sky130_fd_sc_hd__nor2_1
X_6538_ _1988_ _2002_ VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__or2b_1
X_6469_ _2124_ _2127_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_76_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8208_ _3727_ VGND VGND VPWR VPWR _3861_ sky130_fd_sc_hd__inv_2
XFILLER_0_100_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8139_ net35 _3326_ VGND VGND VPWR VPWR _3792_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_34_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5840_ _1439_ _1482_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5771_ _1429_ _1305_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__xnor2_1
X_8490_ _4057_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4722_ _0372_ _4268_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__nand2_1
X_7510_ _3164_ _3154_ _3158_ VGND VGND VPWR VPWR _3165_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7441_ _3076_ _3095_ _3096_ VGND VGND VPWR VPWR _3097_ sky130_fd_sc_hd__a21oi_2
X_4653_ _0248_ _0243_ _0346_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4584_ _4208_ _4324_ _4323_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__or3_1
X_7372_ _2394_ _2981_ _2995_ _3000_ VGND VGND VPWR VPWR _3029_ sky130_fd_sc_hd__a31o_1
X_6323_ _1889_ _1981_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__nand2_1
X_6254_ _0630_ _1912_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5205_ _0816_ _0856_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__o21ai_4
X_6185_ _1843_ _0638_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__nand2_1
X_5136_ _0747_ _0760_ _0761_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__o21ai_1
X_5067_ _0677_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__buf_4
XFILLER_0_67_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8826_ clknet_4_9_0_clk _0200_ VGND VGND VPWR VPWR rf.registers\[5\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_8757_ clknet_4_15_0_clk _0131_ _0030_ VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_82_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5969_ _1612_ _1525_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7708_ _3348_ _2816_ _3338_ VGND VGND VPWR VPWR _3361_ sky130_fd_sc_hd__o21ai_1
X_8688_ clknet_4_11_0_clk _0062_ VGND VGND VPWR VPWR rf.registers\[25\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_7639_ _3283_ _3284_ VGND VGND VPWR VPWR _3294_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold109 rf.registers\[10\]\[11\] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7990_ _3103_ _3642_ VGND VGND VPWR VPWR _3643_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6941_ _2589_ _2592_ _2597_ _0534_ VGND VGND VPWR VPWR _2598_ sky130_fd_sc_hd__a22o_1
X_6872_ _2527_ _2528_ VGND VGND VPWR VPWR _2529_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8611_ net172 _4071_ VGND VGND VPWR VPWR _4105_ sky130_fd_sc_hd__and2_1
X_5823_ _1479_ _1481_ _1456_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8542_ _3995_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__inv_2
XFILLER_0_29_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5754_ _0651_ _1412_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4705_ _0399_ _0400_ _4186_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__mux2_1
X_8473_ _4048_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5685_ net264 _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7424_ _3050_ _3052_ _3058_ VGND VGND VPWR VPWR _3081_ sky130_fd_sc_hd__a21oi_1
X_4636_ _0328_ _0332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7355_ net39 _2917_ VGND VGND VPWR VPWR _3012_ sky130_fd_sc_hd__nand2_1
X_4567_ _0251_ _0261_ _0263_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__o21a_1
X_6306_ _1931_ _1941_ _1945_ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_73_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4498_ _4216_ _4293_ VGND VGND VPWR VPWR _4307_ sky130_fd_sc_hd__nand2_1
X_7286_ _2913_ _2942_ VGND VGND VPWR VPWR _2943_ sky130_fd_sc_hd__and2b_1
X_6237_ _1758_ _1884_ _1790_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__a21boi_1
X_6168_ _1766_ _1803_ _1826_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__o21ba_1
X_5119_ _0642_ _0776_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__xnor2_1
X_6099_ _1676_ _1757_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8809_ clknet_4_6_0_clk _0183_ VGND VGND VPWR VPWR rf.registers\[10\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone32 net93 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__buf_4
Xclone21 _0851_ _0839_ _0852_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_23_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5470_ _1127_ _1128_ _1081_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4421_ _4227_ _4228_ _4229_ VGND VGND VPWR VPWR _4230_ sky130_fd_sc_hd__or3_1
X_4352_ net1 _4143_ imem.address\[0\] VGND VGND VPWR VPWR _4161_ sky130_fd_sc_hd__and3_1
X_7140_ _2762_ _2779_ _2795_ _2796_ VGND VGND VPWR VPWR _2797_ sky130_fd_sc_hd__o22a_1
X_7071_ _0556_ VGND VGND VPWR VPWR _2728_ sky130_fd_sc_hd__inv_2
X_6022_ _1679_ _1680_ _1675_ _1583_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__a22o_1
X_7973_ _3613_ _3615_ _3618_ VGND VGND VPWR VPWR _3626_ sky130_fd_sc_hd__o21a_1
XFILLER_0_55_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6924_ _2526_ _2550_ _2579_ VGND VGND VPWR VPWR _2581_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6855_ _2477_ _2489_ _2475_ VGND VGND VPWR VPWR _2512_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6786_ _2414_ _2420_ _2424_ VGND VGND VPWR VPWR _2443_ sky130_fd_sc_hd__a21o_1
X_5806_ _1417_ _1464_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8525_ _4069_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__inv_2
X_5737_ _1371_ _1380_ _1394_ _1395_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__o31a_1
X_8456_ _4039_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_20_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7407_ _3035_ _3063_ VGND VGND VPWR VPWR _3064_ sky130_fd_sc_hd__xor2_2
X_5668_ _0650_ _1302_ _1298_ _1275_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__o2bb2a_1
X_8387_ _4002_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5599_ _1220_ _1214_ _0643_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__a21o_4
X_4619_ _4267_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__and2b_1
XFILLER_0_102_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7338_ _2985_ _2994_ VGND VGND VPWR VPWR _2995_ sky130_fd_sc_hd__or2_1
X_7269_ _2923_ _2925_ VGND VGND VPWR VPWR _2926_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_8_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_56_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4970_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__buf_6
XFILLER_0_86_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6640_ _2171_ _2175_ _2297_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__and3_1
XFILLER_0_73_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6571_ _0647_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__buf_4
XFILLER_0_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8310_ net85 _3956_ _3806_ VGND VGND VPWR VPWR _3962_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_54_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5522_ _1174_ _1158_ _1180_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8241_ _3684_ net99 VGND VGND VPWR VPWR _3894_ sky130_fd_sc_hd__nor2_1
X_5453_ _1111_ _1108_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__nand2_1
X_8172_ _3736_ _3741_ _3824_ VGND VGND VPWR VPWR _3825_ sky130_fd_sc_hd__or3_1
X_4404_ _4209_ _4210_ _4211_ _4212_ VGND VGND VPWR VPWR _4213_ sky130_fd_sc_hd__or4_1
X_5384_ _0998_ _1042_ _1033_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__mux2_1
X_4335_ imem.address\[3\] imem.address\[2\] VGND VGND VPWR VPWR _4144_ sky130_fd_sc_hd__or2b_1
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7123_ _2756_ _2779_ _2747_ VGND VGND VPWR VPWR _2780_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_70_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7054_ _2689_ _2690_ VGND VGND VPWR VPWR _2711_ sky130_fd_sc_hd__nor2_1
X_6005_ _1582_ _1581_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7956_ _3608_ VGND VGND VPWR VPWR _3609_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_53_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7887_ _3359_ _3539_ VGND VGND VPWR VPWR _3540_ sky130_fd_sc_hd__nor2_1
X_6907_ _0753_ _2388_ _2562_ _2563_ VGND VGND VPWR VPWR _2564_ sky130_fd_sc_hd__o22a_1
X_6838_ _2471_ _2494_ VGND VGND VPWR VPWR _2495_ sky130_fd_sc_hd__xor2_1
X_6769_ _2414_ _2420_ _2418_ VGND VGND VPWR VPWR _2426_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_33_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8508_ _4066_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8439_ _4029_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_79_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7810_ _3379_ _3462_ VGND VGND VPWR VPWR _3463_ sky130_fd_sc_hd__nor2_1
X_8790_ clknet_4_15_0_clk _0164_ VGND VGND VPWR VPWR rf.registers\[10\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4953_ _4180_ _0613_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__nor2_1
X_7741_ _3392_ _3393_ VGND VGND VPWR VPWR _3394_ sky130_fd_sc_hd__or2_1
XFILLER_0_86_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7672_ net110 VGND VGND VPWR VPWR _3327_ sky130_fd_sc_hd__inv_2
X_6623_ _2254_ _2261_ _2280_ _2266_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__or4_4
X_4884_ net64 _0527_ _0564_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6554_ _1486_ _2210_ _2211_ _2212_ _0631_ VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__o32a_1
XFILLER_0_6_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6485_ _2143_ _2138_ _2142_ _2137_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__and4_1
X_5505_ _1163_ _1035_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__or2_4
XFILLER_0_42_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8224_ _3709_ _3869_ _2302_ _3865_ VGND VGND VPWR VPWR _3877_ sky130_fd_sc_hd__o22a_1
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5436_ _1039_ _1044_ _1094_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__or3_1
XFILLER_0_30_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8155_ _3629_ _3807_ VGND VGND VPWR VPWR _3808_ sky130_fd_sc_hd__and2_1
X_5367_ _0928_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__xnor2_1
X_8086_ _1795_ _3737_ _3660_ VGND VGND VPWR VPWR _3739_ sky130_fd_sc_hd__a21oi_1
X_5298_ _0618_ _0874_ _0875_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__o21a_1
X_7106_ _2390_ _2762_ VGND VGND VPWR VPWR _2763_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_98_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7037_ _2656_ _2676_ _2692_ _2693_ VGND VGND VPWR VPWR _2694_ sky130_fd_sc_hd__a22o_1
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7939_ _3587_ _3591_ _3580_ VGND VGND VPWR VPWR _3592_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_77_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6270_ _1822_ _1908_ _1927_ _1928_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__a31o_1
XFILLER_0_11_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5221_ _0800_ _0864_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__nor2_1
X_5152_ _0750_ _0751_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5083_ _0741_ _0718_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8842_ clknet_4_0_0_clk _0216_ VGND VGND VPWR VPWR rf.registers\[5\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8773_ clknet_4_4_0_clk _0147_ _0046_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_93_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7724_ net89 _3375_ _3376_ _3334_ net19 VGND VGND VPWR VPWR _3377_ sky130_fd_sc_hd__o32a_1
X_5985_ _1633_ _1467_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__xnor2_1
X_4936_ _0490_ _0583_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4867_ _4154_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__clkbuf_4
X_7655_ _3299_ _3306_ _3309_ VGND VGND VPWR VPWR _3310_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6606_ _2184_ _2192_ _2233_ _2109_ _2249_ VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__a221o_1
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7586_ net15 _3240_ VGND VGND VPWR VPWR _3241_ sky130_fd_sc_hd__xnor2_1
X_4798_ _0489_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__inv_2
X_6537_ _1987_ _2090_ _2095_ VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__or3_1
XFILLER_0_6_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6468_ _2119_ _2111_ _2125_ _2126_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__o31a_1
XFILLER_0_30_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8207_ _3855_ _3859_ VGND VGND VPWR VPWR _3860_ sky130_fd_sc_hd__xnor2_1
X_6399_ _1895_ _1898_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__and2_1
X_5419_ _1052_ _1053_ _0974_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_7_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8138_ net32 _3790_ VGND VGND VPWR VPWR _3791_ sky130_fd_sc_hd__nor2_1
X_8069_ _2230_ _3721_ VGND VGND VPWR VPWR _3722_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap56 net263 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5770_ _1249_ _1286_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4721_ _0374_ _4257_ _0372_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7440_ _3075_ _3095_ _3074_ VGND VGND VPWR VPWR _3096_ sky130_fd_sc_hd__a21oi_1
X_4652_ _0347_ _0348_ _0339_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7371_ _3022_ _3026_ _2394_ _3027_ VGND VGND VPWR VPWR _3028_ sky130_fd_sc_hd__o2bb2a_1
X_4583_ _4333_ _0277_ _0279_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6322_ _1847_ _1850_ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__and2_1
X_6253_ _1786_ _1911_ _1822_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__mux2_4
XFILLER_0_3_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5204_ _0854_ _0853_ _0862_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__or3b_4
X_6184_ net67 VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__inv_2
X_5135_ _0792_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__and2_1
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5066_ net61 _0724_ net89 VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__mux2_2
XFILLER_0_79_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8825_ clknet_4_8_0_clk _0199_ VGND VGND VPWR VPWR rf.registers\[5\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8756_ clknet_4_15_0_clk _0130_ _0029_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_66_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5968_ _1524_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__inv_2
X_4919_ _0587_ _4156_ _0590_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7707_ _3118_ _1134_ VGND VGND VPWR VPWR _3360_ sky130_fd_sc_hd__nor2_1
X_8687_ clknet_4_11_0_clk _0061_ _0024_ VGND VGND VPWR VPWR imem.address\[4\] sky130_fd_sc_hd__dfrtp_2
X_5899_ _1005_ _1557_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__and2_1
X_7638_ _3291_ _3292_ VGND VGND VPWR VPWR _3293_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7569_ net63 _3219_ _3209_ VGND VGND VPWR VPWR _3224_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_43_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6940_ net62 _2388_ VGND VGND VPWR VPWR _2597_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6871_ _2405_ _2507_ _2522_ _2524_ VGND VGND VPWR VPWR _2528_ sky130_fd_sc_hd__nand4_1
XFILLER_0_49_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5822_ _1480_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__inv_2
X_8610_ _4104_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
X_8541_ _3995_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__inv_2
XFILLER_0_29_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5753_ _1260_ _1411_ _1334_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__mux2_4
XFILLER_0_91_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4704_ _0243_ _0237_ _0346_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8472_ net239 _4045_ VGND VGND VPWR VPWR _4048_ sky130_fd_sc_hd__and2_1
X_5684_ _1234_ _1235_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__or2_1
X_7423_ _3078_ _3079_ VGND VGND VPWR VPWR _3080_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_62_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4635_ _0330_ _0331_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nand2_1
X_4566_ _0247_ _0262_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__nor2_1
X_7354_ _3010_ VGND VGND VPWR VPWR _3011_ sky130_fd_sc_hd__inv_2
XFILLER_0_71_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6305_ net113 VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__buf_4
XFILLER_0_12_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4497_ rf.registers\[25\]\[14\] _4165_ _4174_ rf.registers\[10\]\[14\] VGND VGND
+ VPWR VPWR _4306_ sky130_fd_sc_hd__a22o_1
X_7285_ _2936_ _2938_ _2914_ VGND VGND VPWR VPWR _2942_ sky130_fd_sc_hd__o21ai_1
X_6236_ _1881_ _1823_ _1824_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__or3_1
X_6167_ _1782_ _1794_ _1804_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_71_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5118_ _0642_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__or2_1
X_6098_ _1723_ _1755_ _1756_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__a21o_1
X_5049_ net24 _0658_ _0622_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_43_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8808_ clknet_4_4_0_clk _0182_ VGND VGND VPWR VPWR rf.registers\[10\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_8739_ clknet_4_2_0_clk _0113_ VGND VGND VPWR VPWR rf.registers\[15\]\[19\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_80_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclone22 _0678_ _0676_ net34 _0623_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__o211a_2
XTAP_TAPCELL_ROW_23_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone33 _1333_ _1325_ _0644_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__a21o_2
XTAP_TAPCELL_ROW_51_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_95_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_131 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4420_ rf.registers\[5\]\[21\] _4148_ _4175_ rf.registers\[15\]\[21\] VGND VGND VPWR
+ VPWR _4229_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4351_ _4159_ VGND VGND VPWR VPWR _4160_ sky130_fd_sc_hd__buf_2
XFILLER_0_22_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7070_ _2726_ _2700_ VGND VGND VPWR VPWR _2727_ sky130_fd_sc_hd__xnor2_1
X_6021_ _1673_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__inv_2
XFILLER_0_55_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7972_ _3624_ VGND VGND VPWR VPWR _3625_ sky130_fd_sc_hd__inv_2
XFILLER_0_55_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6923_ _2579_ _2526_ _2550_ VGND VGND VPWR VPWR _2580_ sky130_fd_sc_hd__and3_1
X_6854_ _2475_ _2477_ _2488_ VGND VGND VPWR VPWR _2511_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6785_ _2414_ _2420_ _2424_ VGND VGND VPWR VPWR _2442_ sky130_fd_sc_hd__a21oi_1
X_5805_ _1463_ _1415_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8524_ _4069_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5736_ _1121_ _1369_ _1370_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__nand3_1
X_8455_ net209 _4034_ VGND VGND VPWR VPWR _4039_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5667_ _1275_ _1298_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7406_ _3037_ _3062_ VGND VGND VPWR VPWR _3063_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4618_ _4268_ _4270_ _0314_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__a21bo_1
X_8386_ net159 _0598_ _3997_ VGND VGND VPWR VPWR _4002_ sky130_fd_sc_hd__mux2_1
X_5598_ _1256_ _1120_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__xnor2_2
X_4549_ _0239_ _0245_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__and2_1
X_7337_ _2990_ _2993_ _2394_ _2988_ VGND VGND VPWR VPWR _2994_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7268_ _2918_ _2924_ VGND VGND VPWR VPWR _2925_ sky130_fd_sc_hd__nand2_1
X_6219_ _0638_ _1863_ _1857_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__o21a_1
X_7199_ _2849_ _2850_ VGND VGND VPWR VPWR _2856_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_97_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6570_ _2137_ _2224_ _2226_ _2144_ _2228_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__a221o_1
XFILLER_0_54_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5521_ _0650_ _1175_ _1143_ _1176_ _1179_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__a2111o_1
X_8240_ _3688_ _3892_ _3822_ VGND VGND VPWR VPWR _3893_ sky130_fd_sc_hd__mux2_4
XFILLER_0_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5452_ _0924_ _1103_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8171_ _3732_ _3766_ _3823_ VGND VGND VPWR VPWR _3824_ sky130_fd_sc_hd__a21oi_1
X_4403_ rf.registers\[5\]\[12\] _4147_ _4173_ rf.registers\[15\]\[12\] VGND VGND VPWR
+ VPWR _4212_ sky130_fd_sc_hd__a22o_1
X_5383_ _1040_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__xor2_1
X_4334_ imem.address\[1\] VGND VGND VPWR VPWR _4143_ sky130_fd_sc_hd__buf_2
X_7122_ _2777_ VGND VGND VPWR VPWR _2779_ sky130_fd_sc_hd__buf_2
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7053_ _2402_ _2709_ VGND VGND VPWR VPWR _2710_ sky130_fd_sc_hd__or2_1
X_6004_ _1654_ _1610_ _1662_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7955_ _3601_ _3604_ VGND VGND VPWR VPWR _3608_ sky130_fd_sc_hd__xor2_1
XFILLER_0_82_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7886_ _3538_ _3536_ _3533_ VGND VGND VPWR VPWR _3539_ sky130_fd_sc_hd__o21a_1
X_6906_ _2400_ _2558_ net62 VGND VGND VPWR VPWR _2563_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_92_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6837_ _2478_ _2481_ VGND VGND VPWR VPWR _2494_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6768_ _2414_ _2420_ _2424_ _2386_ _0494_ VGND VGND VPWR VPWR _2425_ sky130_fd_sc_hd__a2111oi_1
XTAP_TAPCELL_ROW_33_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8507_ net157 _4056_ VGND VGND VPWR VPWR _4066_ sky130_fd_sc_hd__and2_1
X_6699_ _2354_ _2355_ VGND VGND VPWR VPWR _2356_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5719_ _1376_ _1377_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8438_ net257 _0448_ _4019_ VGND VGND VPWR VPWR _4029_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_79_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8369_ net5 _3990_ _3994_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4952_ net1 imem.address\[0\] VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__nor2_1
X_7740_ _3389_ _3387_ _3391_ VGND VGND VPWR VPWR _3393_ sky130_fd_sc_hd__and3_1
X_7671_ _3321_ _3323_ _3325_ VGND VGND VPWR VPWR _3326_ sky130_fd_sc_hd__a21o_1
X_4883_ _0562_ _0563_ _0358_ _0356_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_19_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6622_ _2267_ _2277_ _2272_ _2279_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__or4b_4
XFILLER_0_52_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6553_ net40 net7 VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6484_ _2140_ _2141_ _1856_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5504_ _1159_ _1162_ _1116_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__mux2_4
XFILLER_0_42_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8223_ _2276_ _3873_ VGND VGND VPWR VPWR _3876_ sky130_fd_sc_hd__nor2_1
X_5435_ _1091_ _1047_ _1092_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__o211a_1
XFILLER_0_100_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8154_ _3806_ VGND VGND VPWR VPWR _3807_ sky130_fd_sc_hd__inv_2
X_5366_ _0937_ _1015_ _0933_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__a21oi_1
X_8085_ _2325_ _3737_ VGND VGND VPWR VPWR _3738_ sky130_fd_sc_hd__or2_1
X_5297_ _0951_ _0619_ _0953_ _0955_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__a22o_1
X_7105_ _2722_ _2741_ _2761_ _2757_ VGND VGND VPWR VPWR _2762_ sky130_fd_sc_hd__o22a_1
X_7036_ _2658_ _2659_ VGND VGND VPWR VPWR _2693_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_2_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7938_ _3588_ _3590_ VGND VGND VPWR VPWR _3591_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7869_ _3509_ _3514_ VGND VGND VPWR VPWR _3522_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_616 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5220_ _0878_ _0871_ _0865_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__or3_4
XFILLER_0_51_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5151_ _0806_ _0808_ _0618_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__o2bb2a_2
X_5082_ _0736_ _0715_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__and3_1
XFILLER_0_47_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8841_ clknet_4_2_0_clk _0215_ VGND VGND VPWR VPWR rf.registers\[5\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_63_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8772_ clknet_4_6_0_clk _0146_ _0045_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7723_ _3338_ _3200_ _3334_ VGND VGND VPWR VPWR _3376_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5984_ _1641_ _1642_ _1582_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__a21oi_1
X_4935_ _0260_ _0254_ _0259_ _0602_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__o31a_1
XFILLER_0_86_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7654_ _3306_ _3308_ VGND VGND VPWR VPWR _3309_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4866_ net19 _0527_ _0549_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__a21o_1
X_6605_ _2195_ _2215_ VGND VGND VPWR VPWR _2263_ sky130_fd_sc_hd__xnor2_1
X_4797_ _0382_ _0404_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7585_ _3234_ _3236_ _3239_ VGND VGND VPWR VPWR _3240_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_105_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6536_ _2193_ _2194_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__nor2_2
XFILLER_0_104_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6467_ _2064_ _2089_ _2094_ VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__or3_1
X_8206_ _3858_ _3787_ VGND VGND VPWR VPWR _3859_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_76_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6398_ _1970_ _2039_ _2054_ _2056_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__o211a_1
X_5418_ _1075_ _1076_ _0906_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_7_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8137_ net35 _3326_ VGND VGND VPWR VPWR _3790_ sky130_fd_sc_hd__xor2_1
X_5349_ _1007_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__inv_2
X_8068_ _2295_ _3720_ VGND VGND VPWR VPWR _3721_ sky130_fd_sc_hd__xnor2_1
X_7019_ _2658_ _2659_ _2664_ _2666_ VGND VGND VPWR VPWR _2676_ sky130_fd_sc_hd__o31a_1
XFILLER_0_69_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap57 _0583_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_87_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4720_ _0412_ _0415_ _0369_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4651_ _0237_ _0235_ _0346_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7370_ _3020_ VGND VGND VPWR VPWR _3027_ sky130_fd_sc_hd__inv_2
X_4582_ _4329_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__or2_1
X_6321_ _1889_ _1979_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__nand2_2
XFILLER_0_24_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6252_ _1909_ _1910_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__and2_1
X_6183_ _1838_ _1486_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__nand2_1
X_5203_ _0810_ _0817_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__xnor2_1
X_5134_ _0726_ _0791_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__or2_1
X_5065_ _0721_ _0723_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8824_ clknet_4_8_0_clk _0198_ VGND VGND VPWR VPWR rf.registers\[5\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_8755_ clknet_4_14_0_clk _0129_ _0028_ VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5967_ _0651_ _1625_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__xnor2_1
X_8686_ clknet_4_11_0_clk _0060_ _0023_ VGND VGND VPWR VPWR imem.address\[3\] sky130_fd_sc_hd__dfrtp_1
X_4918_ _0405_ net57 _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__a21bo_1
X_7706_ _0573_ _3341_ _3357_ _3358_ VGND VGND VPWR VPWR _3359_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7637_ _3282_ _3288_ VGND VGND VPWR VPWR _3292_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5898_ _1555_ _1556_ _1426_ _1533_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_62_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4849_ _0390_ _0306_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__or2_1
XFILLER_0_35_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7568_ _3222_ VGND VGND VPWR VPWR _3223_ sky130_fd_sc_hd__inv_2
X_6519_ _2071_ _2174_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__xnor2_1
X_7499_ _0505_ _3153_ VGND VGND VPWR VPWR _3154_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6870_ _2405_ _2522_ _2524_ _2507_ VGND VGND VPWR VPWR _2527_ sky130_fd_sc_hd__a31o_1
XFILLER_0_76_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5821_ _1409_ _1413_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__xor2_1
XFILLER_0_91_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8540_ _3995_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__inv_2
X_5752_ _1263_ _1410_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4703_ _0235_ _0227_ _0346_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8471_ _4047_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5683_ _1121_ _1341_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__or2_1
X_7422_ _3061_ _3077_ VGND VGND VPWR VPWR _3079_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4634_ _4239_ _4242_ _0329_ _4179_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__o31a_1
X_4565_ _0244_ _0246_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__and2_1
X_7353_ _2974_ _3000_ _3009_ VGND VGND VPWR VPWR _3010_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6304_ _1832_ _1962_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_73_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4496_ _4303_ _4304_ VGND VGND VPWR VPWR _4305_ sky130_fd_sc_hd__and2b_1
X_7284_ _2913_ _2914_ _2940_ VGND VGND VPWR VPWR _2941_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6235_ _1889_ _1893_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__xnor2_2
X_6166_ _1823_ _1824_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__nor2_1
X_6097_ _1630_ net83 _1700_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__and3_1
X_5117_ _0725_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__xor2_4
X_5048_ _0694_ _0679_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_84_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8807_ clknet_4_1_0_clk _0181_ VGND VGND VPWR VPWR rf.registers\[10\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
X_8738_ clknet_4_8_0_clk _0112_ VGND VGND VPWR VPWR rf.registers\[15\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_6999_ _2654_ _2655_ _2627_ VGND VGND VPWR VPWR _2656_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclone23 _1815_ _1805_ _1817_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__a21o_2
Xclone34 _0735_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_23_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8669_ net146 _4130_ VGND VGND VPWR VPWR _4136_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_51_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4350_ imem.address\[4\] _4143_ _4144_ _4145_ VGND VGND VPWR VPWR _4159_ sky130_fd_sc_hd__or4_1
X_6020_ _1385_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__buf_4
X_7971_ _3335_ _3623_ VGND VGND VPWR VPWR _3624_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6922_ _2551_ _2547_ VGND VGND VPWR VPWR _2579_ sky130_fd_sc_hd__and2b_1
XFILLER_0_76_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6853_ _2498_ _2489_ _2480_ VGND VGND VPWR VPWR _2510_ sky130_fd_sc_hd__a21oi_1
X_5804_ _1409_ _1413_ _1416_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6784_ _2440_ _2387_ _2428_ VGND VGND VPWR VPWR _2441_ sky130_fd_sc_hd__or3b_1
XFILLER_0_17_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8523_ _4069_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__inv_2
X_5735_ _1387_ _1391_ _1393_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8454_ _4038_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_20_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5666_ _1249_ _1286_ _1324_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__a21o_4
X_7405_ _3044_ _3059_ VGND VGND VPWR VPWR _3062_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4617_ _4273_ _0312_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__o21ai_1
X_8385_ _4001_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5597_ _1166_ _1255_ _1221_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__mux2_4
XFILLER_0_102_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4548_ _0238_ _0232_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__or2_1
X_7336_ _2970_ _2978_ _2992_ VGND VGND VPWR VPWR _2993_ sky130_fd_sc_hd__nor3_1
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4479_ _4223_ _4287_ VGND VGND VPWR VPWR _4288_ sky130_fd_sc_hd__xor2_1
X_7267_ _2899_ _2911_ _2902_ VGND VGND VPWR VPWR _2924_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_40_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6218_ _1867_ _1676_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__xnor2_2
X_7198_ _2819_ _2837_ _2854_ VGND VGND VPWR VPWR _2855_ sky130_fd_sc_hd__mux2_1
X_6149_ _1674_ _1806_ _1723_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5520_ _1078_ _1080_ _1134_ _1178_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__o31a_1
XFILLER_0_41_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5451_ _1039_ _1094_ _1044_ _1038_ _1109_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__o311a_1
X_8170_ _3774_ _3775_ _3778_ VGND VGND VPWR VPWR _3823_ sky130_fd_sc_hd__nand3_1
X_4402_ rf.registers\[5\]\[13\] _4148_ _4173_ rf.registers\[15\]\[13\] VGND VGND VPWR
+ VPWR _4211_ sky130_fd_sc_hd__a22o_1
X_5382_ _0992_ _0995_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7121_ _2747_ _2756_ _2777_ VGND VGND VPWR VPWR _2778_ sky130_fd_sc_hd__and3_1
X_7052_ _2669_ _2702_ _2707_ _2708_ VGND VGND VPWR VPWR _2709_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6003_ _1656_ _1632_ _1658_ _1661_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__a211o_1
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7954_ _3602_ _3606_ _3593_ VGND VGND VPWR VPWR _3607_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6905_ net62 _2399_ _2558_ VGND VGND VPWR VPWR _2562_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7885_ _3359_ _3537_ VGND VGND VPWR VPWR _3538_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6836_ _2399_ _2492_ VGND VGND VPWR VPWR _2493_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6767_ _2415_ _2412_ _0480_ _2411_ VGND VGND VPWR VPWR _2424_ sky130_fd_sc_hd__o211a_1
X_5718_ _0635_ _1274_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_33_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8506_ _4065_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
X_6698_ _2276_ _2353_ VGND VGND VPWR VPWR _2355_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5649_ _1206_ _1307_ _1231_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__mux2_1
X_8437_ _4028_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_79_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8368_ _0614_ _0813_ net244 _3988_ _3327_ VGND VGND VPWR VPWR _3994_ sky130_fd_sc_hd__a41o_1
XFILLER_0_32_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7319_ _2208_ _2917_ _2973_ VGND VGND VPWR VPWR _2976_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8299_ net32 net21 _3796_ VGND VGND VPWR VPWR _3952_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_69_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4951_ _4162_ _0612_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7670_ _3316_ _3319_ _3324_ _3310_ VGND VGND VPWR VPWR _3325_ sky130_fd_sc_hd__a2bb2o_1
X_4882_ _0295_ _4309_ _0293_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__and3_1
X_6621_ net77 _2273_ _2278_ _1970_ VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__a211o_1
XFILLER_0_27_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6552_ _2208_ net82 _2101_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__and3_1
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6483_ _1856_ _2140_ _2141_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__nand3_1
XFILLER_0_54_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5503_ _1060_ _1160_ _1056_ _1161_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__a2bb2o_1
X_8222_ _2230_ _3860_ _3865_ _2302_ _3874_ VGND VGND VPWR VPWR _3875_ sky130_fd_sc_hd__a221o_1
X_5434_ _0634_ _1043_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__or2_1
X_8153_ _3798_ _3805_ VGND VGND VPWR VPWR _3806_ sky130_fd_sc_hd__xor2_2
XFILLER_0_100_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5365_ _1017_ _1023_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__and2_1
X_7104_ _2723_ _2734_ _2741_ VGND VGND VPWR VPWR _2761_ sky130_fd_sc_hd__o21ai_1
X_8084_ _2330_ _3733_ _2328_ VGND VGND VPWR VPWR _3737_ sky130_fd_sc_hd__o21a_1
XFILLER_0_10_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5296_ _0954_ _0633_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nand2_1
X_7035_ _2658_ _2659_ _2676_ VGND VGND VPWR VPWR _2692_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_97_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7937_ _3576_ _3589_ _3573_ VGND VGND VPWR VPWR _3590_ sky130_fd_sc_hd__mux2_1
X_7868_ _3519_ _3520_ VGND VGND VPWR VPWR _3521_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6819_ _0505_ _2454_ VGND VGND VPWR VPWR _2476_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_37_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7799_ _3443_ _3441_ VGND VGND VPWR VPWR _3452_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5150_ _0534_ _0788_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5081_ _0701_ _0713_ _0699_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8840_ clknet_4_0_0_clk _0214_ VGND VGND VPWR VPWR rf.registers\[5\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8771_ clknet_4_6_0_clk _0145_ _0044_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfrtp_4
X_5983_ net70 _1634_ _1477_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__a21o_1
X_4934_ _0390_ _0261_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7722_ _3118_ _2605_ VGND VGND VPWR VPWR _3375_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7653_ _3307_ _3300_ _3301_ VGND VGND VPWR VPWR _3308_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4865_ _0545_ _0546_ _0547_ _0548_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6604_ _2109_ _2233_ _2249_ VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__a21oi_4
X_4796_ _0397_ _0401_ _0344_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7584_ _3221_ _3237_ _3238_ VGND VGND VPWR VPWR _3239_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6535_ _1970_ _2184_ _2192_ VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__and3_1
X_8205_ _3856_ net50 VGND VGND VPWR VPWR _3858_ sky130_fd_sc_hd__nor2_1
X_6466_ _2065_ _2051_ _2057_ VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__and3_1
XFILLER_0_30_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6397_ _1970_ _2039_ _2055_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__a21bo_1
X_5417_ _0872_ _1073_ _1031_ _0980_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_7_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8136_ _3348_ _3659_ _3788_ net3 VGND VGND VPWR VPWR _3789_ sky130_fd_sc_hd__o211a_1
X_5348_ _0943_ _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__and2b_1
X_8067_ _2287_ _2290_ net73 _3660_ VGND VGND VPWR VPWR _3720_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_10_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5279_ _0933_ _0937_ _0929_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__nor3b_2
X_7018_ _2633_ _2634_ _2627_ _2638_ VGND VGND VPWR VPWR _2675_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_87_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap58 _2425_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4650_ _0227_ _0222_ _0346_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4581_ _4326_ _4328_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__nor2_1
X_6320_ _1969_ _1978_ _1964_ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6251_ _1765_ _1780_ _1908_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__nand3_1
X_6182_ net66 _1823_ _1824_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__or3_1
X_5202_ _0643_ _0860_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__xnor2_1
X_5133_ _0726_ _0791_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__nand2_1
X_5064_ _0722_ _0674_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8823_ clknet_4_8_0_clk _0197_ VGND VGND VPWR VPWR rf.registers\[5\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8754_ clknet_4_14_0_clk _0128_ _0027_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_66_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5966_ _1521_ _1624_ _1568_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__mux2_4
X_8685_ clknet_4_11_0_clk _0059_ _0022_ VGND VGND VPWR VPWR imem.address\[2\] sky130_fd_sc_hd__dfrtp_2
X_4917_ _0271_ _0236_ _0269_ _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__a31o_1
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7705_ _3329_ _3256_ _3341_ VGND VGND VPWR VPWR _3358_ sky130_fd_sc_hd__a21oi_1
X_5897_ _1427_ _1554_ _1533_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__o21a_1
XFILLER_0_90_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7636_ net39 _3290_ VGND VGND VPWR VPWR _3291_ sky130_fd_sc_hd__nor2_1
X_4848_ net22 VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__buf_6
XFILLER_0_105_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4779_ _0470_ _0471_ _0445_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__mux2_1
X_7567_ _0556_ _3221_ VGND VGND VPWR VPWR _3222_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6518_ _0647_ _2166_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7498_ _0494_ _3152_ VGND VGND VPWR VPWR _3153_ sky130_fd_sc_hd__xor2_1
X_6449_ _2106_ _2107_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__or2_2
XFILLER_0_100_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8119_ _3769_ _3771_ VGND VGND VPWR VPWR _3772_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5820_ _1412_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5751_ _0952_ _1260_ _1261_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__o21a_1
XFILLER_0_84_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8470_ net214 _4045_ VGND VGND VPWR VPWR _4047_ sky130_fd_sc_hd__and2_1
X_4702_ _0394_ _0397_ _0344_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7421_ _3061_ _3077_ VGND VGND VPWR VPWR _3078_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5682_ _1222_ _1335_ _1338_ _1340_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__o22a_1
X_4633_ _4239_ _4242_ _0329_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_102_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4564_ _0254_ _0259_ _0260_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__o21a_1
X_7352_ _3000_ _3008_ VGND VGND VPWR VPWR _3009_ sky130_fd_sc_hd__nor2_1
XFILLER_0_71_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6303_ _1836_ _1949_ net113 VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__and3_1
X_7283_ _2939_ VGND VGND VPWR VPWR _2940_ sky130_fd_sc_hd__inv_2
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4495_ rf.registers\[25\]\[15\] _4165_ _4174_ rf.registers\[10\]\[15\] VGND VGND
+ VPWR VPWR _4304_ sky130_fd_sc_hd__a22o_1
X_6234_ _1745_ _1892_ _1822_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6165_ _1820_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__inv_2
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6096_ _1737_ _1754_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__or2_1
X_5116_ net91 _0622_ _0720_ _0734_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__or4_2
X_5047_ _0705_ _0648_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6998_ _2617_ _2622_ VGND VGND VPWR VPWR _2655_ sky130_fd_sc_hd__xor2_1
XFILLER_0_39_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8806_ clknet_4_1_0_clk _0180_ VGND VGND VPWR VPWR rf.registers\[10\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_8737_ clknet_4_8_0_clk _0111_ VGND VGND VPWR VPWR rf.registers\[15\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_5949_ _0636_ _1607_ _1599_ _1597_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__o22a_1
XFILLER_0_75_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8668_ _4135_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone46 _1960_ _1953_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__nand2_4
X_7619_ _1838_ _3273_ VGND VGND VPWR VPWR _3274_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8599_ net163 _4094_ VGND VGND VPWR VPWR _4099_ sky130_fd_sc_hd__and2_1
XFILLER_0_50_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7970_ _3340_ _3619_ VGND VGND VPWR VPWR _3623_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6921_ _2564_ _2569_ _2575_ _2576_ _2577_ VGND VGND VPWR VPWR _2578_ sky130_fd_sc_hd__a2111o_1
X_6852_ _2498_ _2480_ _2488_ VGND VGND VPWR VPWR _2509_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5803_ _0651_ _1461_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__xnor2_1
X_8522_ _4069_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__inv_2
X_6783_ _2430_ _2431_ VGND VGND VPWR VPWR _2440_ sky130_fd_sc_hd__or2_1
X_5734_ _1252_ net71 _0635_ _1392_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__o211a_1
X_8453_ net138 _4034_ VGND VGND VPWR VPWR _4038_ sky130_fd_sc_hd__or2b_1
XFILLER_0_72_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5665_ _1300_ _1305_ net54 _1323_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__nand4bb_4
X_8384_ net215 _0601_ _3997_ VGND VGND VPWR VPWR _4001_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7404_ _2395_ _3060_ VGND VGND VPWR VPWR _3061_ sky130_fd_sc_hd__nand2_1
X_4616_ _4268_ _4270_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__xor2_1
X_7335_ _2987_ _2991_ VGND VGND VPWR VPWR _2992_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5596_ _1166_ _1168_ _1254_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_102_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4547_ _0243_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__inv_2
XFILLER_0_20_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4478_ _4179_ _4222_ VGND VGND VPWR VPWR _4287_ sky130_fd_sc_hd__nand2_1
X_7266_ _2898_ _2922_ VGND VGND VPWR VPWR _2923_ sky130_fd_sc_hd__xor2_1
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6217_ _0638_ _1863_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__and2_1
X_7197_ _2846_ _2849_ _2850_ _2853_ VGND VGND VPWR VPWR _2854_ sky130_fd_sc_hd__a31o_2
X_6148_ _1674_ _1806_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__nor2_1
X_6079_ _1660_ _1737_ _1659_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_56_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_106_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5450_ _0691_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__inv_2
X_4401_ rf.registers\[5\]\[11\] _4147_ _4172_ rf.registers\[15\]\[11\] VGND VGND VPWR
+ VPWR _4210_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5381_ _1001_ _0999_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7120_ _2760_ _2763_ _2774_ _2776_ VGND VGND VPWR VPWR _2777_ sky130_fd_sc_hd__o31ai_2
X_7051_ _2705_ _2706_ VGND VGND VPWR VPWR _2708_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
X_6002_ _1617_ _1622_ _1659_ _1660_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__and4_1
XFILLER_0_96_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7953_ _3601_ _3596_ _3599_ VGND VGND VPWR VPWR _3606_ sky130_fd_sc_hd__or3_1
XFILLER_0_77_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6904_ _2388_ _2560_ VGND VGND VPWR VPWR _2561_ sky130_fd_sc_hd__or2_1
XFILLER_0_106_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7884_ _3363_ _3534_ VGND VGND VPWR VPWR _3537_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_53_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6835_ _2483_ _2489_ _2490_ _2491_ VGND VGND VPWR VPWR _2492_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6766_ _0480_ _2397_ VGND VGND VPWR VPWR _2423_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5717_ _1253_ _1374_ _1375_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__o21bai_1
XTAP_TAPCELL_ROW_33_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8505_ net183 _4056_ VGND VGND VPWR VPWR _4065_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6697_ _2276_ _2353_ VGND VGND VPWR VPWR _2354_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5648_ _1209_ _1306_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__xnor2_1
X_8436_ net206 _0467_ _4019_ VGND VGND VPWR VPWR _4028_ sky130_fd_sc_hd__mux2_1
XFILLER_0_103_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_79_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5579_ _1236_ _1237_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__or2_1
X_8367_ _0614_ _3993_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__xnor2_1
X_8298_ _3931_ _3927_ _3946_ _3950_ VGND VGND VPWR VPWR _3951_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_92_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7318_ _2394_ _2974_ VGND VGND VPWR VPWR _2975_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_68_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7249_ _2865_ _2905_ net53 VGND VGND VPWR VPWR _2906_ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_86_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4950_ _4143_ _4180_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4881_ _0390_ _0296_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6620_ _2256_ _2257_ _2258_ _2274_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__o211a_1
X_6551_ _2100_ _2101_ _2209_ _2000_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_61_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5502_ _1159_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__inv_2
X_6482_ _2033_ _2089_ _2094_ VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_30_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8221_ _3869_ _3709_ _3873_ _2276_ VGND VGND VPWR VPWR _3874_ sky130_fd_sc_hd__a22o_1
X_5433_ _0643_ _1046_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8152_ _3802_ _3804_ VGND VGND VPWR VPWR _3805_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5364_ _1021_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__nor2_1
X_7103_ _2402_ _2759_ VGND VGND VPWR VPWR _2760_ sky130_fd_sc_hd__nor2_1
X_8083_ _1795_ _3735_ VGND VGND VPWR VPWR _3736_ sky130_fd_sc_hd__and2_1
X_5295_ net63 VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__inv_2
X_7034_ _2674_ net56 _2688_ _2689_ _2690_ VGND VGND VPWR VPWR _2691_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7936_ _3564_ VGND VGND VPWR VPWR _3589_ sky130_fd_sc_hd__inv_2
XFILLER_0_37_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7867_ _3508_ _3516_ VGND VGND VPWR VPWR _3520_ sky130_fd_sc_hd__xor2_1
X_6818_ _2465_ _2473_ _2474_ VGND VGND VPWR VPWR _2475_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7798_ _3448_ _3446_ VGND VGND VPWR VPWR _3451_ sky130_fd_sc_hd__or2_1
X_6749_ net34 net33 VGND VGND VPWR VPWR _2406_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8419_ _4241_ VGND VGND VPWR VPWR _4019_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_103_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5080_ _0682_ _0736_ _0738_ _0720_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__o22a_1
XFILLER_0_79_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8770_ clknet_4_7_0_clk _0144_ _0043_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfrtp_4
X_5982_ _1477_ _1569_ _1634_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__nand3_2
X_4933_ net35 _4156_ _0601_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7721_ net18 _3373_ _3334_ VGND VGND VPWR VPWR _3374_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_526 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7652_ _3300_ _3303_ VGND VGND VPWR VPWR _3307_ sky130_fd_sc_hd__nand2_1
X_4864_ _0390_ _0302_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__nor2_1
X_6603_ _2172_ _2260_ VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__xnor2_2
X_4795_ _0485_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_15_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7583_ net64 _3235_ VGND VGND VPWR VPWR _3238_ sky130_fd_sc_hd__or2_1
XFILLER_0_103_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6534_ _2184_ _2192_ _1970_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6465_ _1889_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__buf_4
XFILLER_0_12_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8204_ net86 _3675_ _3680_ _3707_ _3673_ VGND VGND VPWR VPWR _3857_ sky130_fd_sc_hd__o41ai_2
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5416_ _1052_ _1074_ _1053_ _0980_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_76_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6396_ _1889_ _2033_ VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_7_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8135_ _3348_ _3787_ VGND VGND VPWR VPWR _3788_ sky130_fd_sc_hd__nand2_1
X_5347_ _0633_ _0947_ _0944_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__or3_1
X_8066_ _3709_ net103 _3718_ VGND VGND VPWR VPWR _3719_ sky130_fd_sc_hd__a21oi_2
X_5278_ _0920_ _0934_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__nor2_1
X_7017_ net63 _2401_ VGND VGND VPWR VPWR _2674_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap59 _4188_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_87_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7919_ _3564_ _3567_ VGND VGND VPWR VPWR _3572_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4580_ _0226_ _0275_ _0276_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6250_ _1780_ _1908_ _1765_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__a21o_1
X_6181_ net90 _1837_ _1839_ _1709_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__a211o_1
X_5201_ _0835_ net81 _0859_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__a21oi_1
X_5132_ _0739_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__xor2_1
X_5063_ net61 _0656_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__nand2_2
X_8822_ clknet_4_10_0_clk _0196_ VGND VGND VPWR VPWR rf.registers\[5\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8753_ clknet_4_14_0_clk _0127_ _0026_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfrtp_2
X_5965_ _1522_ _1623_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__xnor2_1
X_8684_ clknet_4_11_0_clk _0058_ _0021_ VGND VGND VPWR VPWR imem.address\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_90_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4916_ _4154_ _0272_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nand2_1
X_7704_ _3119_ _2854_ _3356_ _3328_ VGND VGND VPWR VPWR _3357_ sky130_fd_sc_hd__a211o_1
X_5896_ _1427_ _1554_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__nand2_1
X_7635_ _3288_ _3289_ VGND VGND VPWR VPWR _3290_ sky130_fd_sc_hd__or2_1
XFILLER_0_74_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4847_ net62 _0527_ _0533_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4778_ _0340_ _0368_ _0383_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__mux2_1
X_7566_ net63 _3216_ _3212_ _3220_ VGND VGND VPWR VPWR _3221_ sky130_fd_sc_hd__a31o_1
X_6517_ _2171_ _2175_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__nand2_1
X_7497_ _3147_ _3149_ _3151_ VGND VGND VPWR VPWR _3152_ sky130_fd_sc_hd__a21o_1
X_6448_ _1968_ _2097_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6379_ _1924_ _2037_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__xnor2_1
X_8118_ _2318_ _3660_ _3767_ _3770_ VGND VGND VPWR VPWR _3771_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8049_ net7 _3699_ _3700_ _3701_ VGND VGND VPWR VPWR _3702_ sky130_fd_sc_hd__o2bb2a_2
XTAP_TAPCELL_ROW_89_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5750_ _0619_ _1405_ _1407_ _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__a22oi_4
X_4701_ _0395_ _0396_ _0339_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__mux2_1
X_5681_ _1335_ _1339_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7420_ _3065_ _3072_ _3076_ VGND VGND VPWR VPWR _3077_ sky130_fd_sc_hd__and3_1
X_4632_ rf.registers\[5\]\[31\] _4150_ _4241_ rf.registers\[15\]\[31\] VGND VGND VPWR
+ VPWR _0329_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4563_ _0248_ _0250_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__xor2_1
X_7351_ net40 _2976_ _2975_ VGND VGND VPWR VPWR _3008_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6302_ _1960_ net114 VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__nand2_8
XFILLER_0_69_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4494_ _4163_ _4217_ _4302_ VGND VGND VPWR VPWR _4303_ sky130_fd_sc_hd__and3_1
X_7282_ _2936_ _2938_ VGND VGND VPWR VPWR _2939_ sky130_fd_sc_hd__nor2_2
XFILLER_0_52_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6233_ _1746_ _1891_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_31_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6164_ _1805_ _1815_ _1817_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__a21oi_4
X_5115_ _0616_ _0770_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__a21oi_1
X_6095_ _1736_ _1733_ _1735_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__and3_1
X_5046_ _0695_ _0704_ _0679_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__mux2_4
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6997_ _2621_ VGND VGND VPWR VPWR _2654_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_40_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8805_ clknet_4_3_0_clk _0179_ VGND VGND VPWR VPWR rf.registers\[10\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_8736_ clknet_4_8_0_clk _0110_ VGND VGND VPWR VPWR rf.registers\[15\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5948_ _1482_ _1570_ _1606_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_48_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone25 net107 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_6
XFILLER_0_90_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone14 _0855_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_23_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5879_ _1533_ _1536_ _1537_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__a21oi_1
X_8667_ net181 _4130_ VGND VGND VPWR VPWR _4135_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_51_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7618_ _3259_ _3261_ _3264_ _3268_ _3272_ VGND VGND VPWR VPWR _3273_ sky130_fd_sc_hd__a221o_1
XFILLER_0_35_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8598_ _4098_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7549_ net20 _3200_ VGND VGND VPWR VPWR _3204_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_59_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6920_ _2557_ _2559_ _2388_ VGND VGND VPWR VPWR _2577_ sky130_fd_sc_hd__a21oi_1
X_6851_ _2502_ _2503_ _2405_ _2507_ VGND VGND VPWR VPWR _2508_ sky130_fd_sc_hd__o211a_1
X_5802_ _1456_ _1459_ _1460_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__a21o_1
X_8521_ _4069_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__inv_2
X_6782_ _2427_ _2426_ _2437_ _2438_ VGND VGND VPWR VPWR _2439_ sky130_fd_sc_hd__a22o_1
XFILLER_0_45_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5733_ _1333_ _1325_ _1389_ _0644_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__a211o_1
X_8452_ _4037_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5664_ net264 _1320_ _1322_ _1029_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__o211a_1
X_8383_ _4000_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
X_7403_ _3033_ _3047_ _3059_ VGND VGND VPWR VPWR _3060_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_20_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5595_ _0952_ _1166_ _1169_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__o21ai_1
X_4615_ _4274_ _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__nor2_1
X_4546_ rf.registers\[25\]\[3\] _4164_ _4171_ rf.registers\[10\]\[3\] VGND VGND VPWR
+ VPWR _0243_ sky130_fd_sc_hd__a22o_1
X_7334_ _2961_ _2986_ VGND VGND VPWR VPWR _2991_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7265_ _2895_ _2911_ VGND VGND VPWR VPWR _2922_ sky130_fd_sc_hd__or2_1
X_4477_ rf.registers\[25\]\[19\] _4166_ _4175_ rf.registers\[10\]\[19\] VGND VGND
+ VPWR VPWR _4286_ sky130_fd_sc_hd__a22o_1
X_6216_ _1860_ _1864_ _1868_ _1874_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__nand4_1
X_7196_ _2797_ _2814_ _2851_ _2852_ VGND VGND VPWR VPWR _2853_ sky130_fd_sc_hd__a211oi_1
X_6147_ _1574_ _1668_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6078_ _1733_ _1735_ _1736_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_56_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5029_ net31 _0676_ net89 VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_28_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8719_ clknet_4_7_0_clk _0093_ VGND VGND VPWR VPWR rf.registers\[25\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_106_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4400_ _4208_ VGND VGND VPWR VPWR _4209_ sky130_fd_sc_hd__inv_2
XFILLER_0_41_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5380_ _1035_ _1037_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7050_ _2705_ _2706_ _2702_ VGND VGND VPWR VPWR _2707_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_105_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6001_ _1484_ _1625_ _1630_ _0636_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__o22ai_1
X_7952_ _3593_ _3596_ _3599_ _3604_ VGND VGND VPWR VPWR _3605_ sky130_fd_sc_hd__a31o_1
X_6903_ _2557_ _2559_ VGND VGND VPWR VPWR _2560_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7883_ _3363_ _3527_ _3530_ _3535_ VGND VGND VPWR VPWR _3536_ sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_53_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6834_ _2486_ _2483_ _2459_ _2487_ VGND VGND VPWR VPWR _2491_ sky130_fd_sc_hd__o211a_1
XFILLER_0_49_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6765_ _0673_ _2421_ VGND VGND VPWR VPWR _2422_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5716_ _1275_ _1252_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_33_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8504_ _4064_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
X_6696_ _2349_ _2352_ _2283_ VGND VGND VPWR VPWR _2353_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8435_ _4027_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5647_ _1195_ _1199_ _1218_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_103_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5578_ _0726_ _1142_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__nor2_1
X_8366_ _0658_ _3990_ VGND VGND VPWR VPWR _3993_ sky130_fd_sc_hd__or2_1
X_8297_ _2396_ _3947_ _3948_ _3949_ _3119_ VGND VGND VPWR VPWR _3950_ sky130_fd_sc_hd__o2111a_1
XTAP_TAPCELL_ROW_92_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4529_ _0223_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__nor2_1
X_7317_ _1843_ _2968_ _2971_ _2973_ VGND VGND VPWR VPWR _2974_ sky130_fd_sc_hd__o22a_1
XFILLER_0_13_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7248_ _2866_ _2904_ VGND VGND VPWR VPWR _2905_ sky130_fd_sc_hd__xor2_1
X_7179_ _2820_ _2834_ VGND VGND VPWR VPWR _2836_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_5_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4880_ _0556_ _0527_ _0561_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6550_ _2208_ _0639_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5501_ _0952_ _1159_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6481_ _2133_ _2139_ _2100_ _2101_ VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_14_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8220_ net104 _3872_ _3822_ VGND VGND VPWR VPWR _3873_ sky130_fd_sc_hd__mux2_4
XFILLER_0_14_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5432_ _1051_ _1083_ _1065_ _1090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__o31a_1
X_8151_ _3622_ _3624_ _3803_ VGND VGND VPWR VPWR _3804_ sky130_fd_sc_hd__o21ai_1
X_5363_ _0924_ _1020_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7102_ _2736_ _2758_ _2745_ _2715_ VGND VGND VPWR VPWR _2759_ sky130_fd_sc_hd__a2bb2o_1
X_8082_ _2327_ _3734_ _2384_ VGND VGND VPWR VPWR _3735_ sky130_fd_sc_hd__mux2_1
X_5294_ _0876_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nand2_1
X_7033_ _2670_ _2671_ _2401_ VGND VGND VPWR VPWR _2690_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_2_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7935_ _3580_ _3587_ VGND VGND VPWR VPWR _3588_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7866_ _3366_ _3518_ VGND VGND VPWR VPWR _3519_ sky130_fd_sc_hd__and2_1
XFILLER_0_92_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6817_ _2454_ _2456_ _2457_ _2466_ VGND VGND VPWR VPWR _2474_ sky130_fd_sc_hd__a211o_1
XFILLER_0_37_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7797_ _3449_ VGND VGND VPWR VPWR _3450_ sky130_fd_sc_hd__inv_2
X_6748_ net24 _2398_ VGND VGND VPWR VPWR _2405_ sky130_fd_sc_hd__nand2_2
XFILLER_0_33_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6679_ _2142_ _2143_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8418_ _4018_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
X_8349_ display.refresh_counter\[10\] _3980_ net124 VGND VGND VPWR VPWR _3983_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_56_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_64_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5981_ _1638_ _1639_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__nand2_1
X_4932_ _0476_ _0583_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7720_ _3118_ _2627_ _3214_ _3328_ net101 VGND VGND VPWR VPWR _3373_ sky130_fd_sc_hd__a221o_1
XFILLER_0_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7651_ _0591_ _3305_ VGND VGND VPWR VPWR _3306_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6602_ net76 _2255_ _2259_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__a21o_1
X_4863_ _0301_ _4297_ _0300_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__or3_1
X_4794_ _0394_ _0415_ _0383_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7582_ _3222_ _3225_ _3226_ VGND VGND VPWR VPWR _3237_ sky130_fd_sc_hd__o21a_1
XFILLER_0_104_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6533_ _2090_ _2095_ _2190_ _2191_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_15_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6464_ _2071_ _2122_ VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8203_ _3685_ _3675_ _3679_ _3690_ VGND VGND VPWR VPWR _3856_ sky130_fd_sc_hd__nor4bb_1
XFILLER_0_88_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5415_ _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__inv_2
X_6395_ _2034_ _2052_ _2040_ _2053_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__nand4_1
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8134_ net93 VGND VGND VPWR VPWR _3787_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_7_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5346_ _0872_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__buf_4
X_8065_ net6 _3717_ _3715_ _2287_ VGND VGND VPWR VPWR _3718_ sky130_fd_sc_hd__o2bb2a_2
X_5277_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__inv_2
X_7016_ _2401_ _2672_ VGND VGND VPWR VPWR _2673_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap49 net50 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7918_ net39 _3570_ net2 VGND VGND VPWR VPWR _3571_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7849_ _3493_ _3499_ VGND VGND VPWR VPWR _3502_ sky130_fd_sc_hd__and2_1
XFILLER_0_92_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6180_ _1838_ _0637_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5200_ _0831_ _0853_ _0854_ _0834_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__o31a_1
X_5131_ _0769_ _0789_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5062_ _0671_ _0672_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8821_ clknet_4_10_0_clk _0195_ VGND VGND VPWR VPWR rf.registers\[5\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8752_ clknet_4_14_0_clk _0126_ _0025_ VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_87_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7703_ _3119_ _1258_ VGND VGND VPWR VPWR _3356_ sky130_fd_sc_hd__nor2_1
X_5964_ _1385_ _1524_ _1613_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__a21oi_1
X_8683_ clknet_4_11_0_clk _0057_ _0020_ VGND VGND VPWR VPWR imem.address\[0\] sky130_fd_sc_hd__dfrtp_4
X_4915_ net38 VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__buf_4
X_5895_ _1428_ _1553_ _1342_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__o21a_1
X_7634_ _2208_ _3287_ VGND VGND VPWR VPWR _3289_ sky130_fd_sc_hd__nor2_1
X_4846_ _4158_ _0529_ _0530_ _0532_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7565_ net63 _3219_ VGND VGND VPWR VPWR _3220_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6516_ _2172_ _2174_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__nand2_1
X_4777_ _0377_ _0363_ _0369_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7496_ _3150_ _3140_ _3143_ VGND VGND VPWR VPWR _3151_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6447_ _2102_ _2096_ _2104_ _2105_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__a31o_1
XFILLER_0_30_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6378_ _0630_ _1912_ _1933_ _2031_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__a22o_1
X_8117_ _2321_ _3738_ VGND VGND VPWR VPWR _3770_ sky130_fd_sc_hd__nand2_1
X_5329_ _0910_ _0939_ _0966_ _0872_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__a211o_1
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8048_ _0591_ net6 VGND VGND VPWR VPWR _3701_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_89_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4700_ _0222_ _4330_ _0335_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5680_ _1327_ _1336_ _1295_ _1326_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__a211o_1
XFILLER_0_60_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4631_ rf.registers\[25\]\[31\] _4167_ _4177_ rf.registers\[10\]\[31\] VGND VGND
+ VPWR VPWR _0328_ sky130_fd_sc_hd__a22o_1
X_4562_ _0256_ _0258_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__nor2_1
X_7350_ net40 _3006_ VGND VGND VPWR VPWR _3007_ sky130_fd_sc_hd__xnor2_1
X_6301_ _1959_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__buf_6
XFILLER_0_69_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4493_ _4214_ _4294_ VGND VGND VPWR VPWR _4302_ sky130_fd_sc_hd__nand2_1
X_7281_ _2886_ _2911_ _2937_ VGND VGND VPWR VPWR _2938_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6232_ _1741_ _1885_ _1890_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__a21o_1
X_6163_ _1821_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__buf_6
X_6094_ _1751_ _1752_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__and2b_1
X_5114_ _0648_ _0772_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__and2_1
X_5045_ net25 _0694_ _0623_ _0702_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__a32o_1
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6996_ _2632_ _2649_ _2652_ VGND VGND VPWR VPWR _2653_ sky130_fd_sc_hd__a21o_1
X_8804_ clknet_4_3_0_clk _0178_ VGND VGND VPWR VPWR rf.registers\[10\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8735_ clknet_4_8_0_clk _0109_ VGND VGND VPWR VPWR rf.registers\[15\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5947_ _1570_ _1605_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8666_ _4134_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
Xclone15 _2070_ _1980_ _2076_ _2088_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__a211o_2
X_7617_ _3269_ _3271_ VGND VGND VPWR VPWR _3272_ sky130_fd_sc_hd__and2_1
X_5878_ _1435_ _1533_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_51_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4829_ _4194_ _0238_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__or2_2
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8597_ rf.registers\[10\]\[23\] _4094_ VGND VGND VPWR VPWR _4098_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7548_ _3201_ _3202_ VGND VGND VPWR VPWR _3203_ sky130_fd_sc_hd__nand2_1
X_7479_ _0673_ _3127_ VGND VGND VPWR VPWR _3134_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_59_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6850_ _2504_ _2506_ _2488_ VGND VGND VPWR VPWR _2507_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6781_ _2423_ _2425_ VGND VGND VPWR VPWR _2438_ sky130_fd_sc_hd__or2_1
X_5801_ _1456_ _1458_ _1457_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__a21oi_1
X_8520_ _4069_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__inv_2
XFILLER_0_71_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5732_ _1252_ net100 _1390_ _0635_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__a211o_1
XFILLER_0_72_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8451_ net255 _4034_ VGND VGND VPWR VPWR _4037_ sky130_fd_sc_hd__or2b_1
X_5663_ _1200_ _1321_ _1202_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__o21bai_1
X_8382_ net219 _0604_ _3997_ VGND VGND VPWR VPWR _4000_ sky130_fd_sc_hd__mux2_1
X_7402_ _3053_ _3056_ _3058_ VGND VGND VPWR VPWR _3059_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5594_ _0971_ _1252_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__and2_4
X_4614_ _4275_ _4277_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__o21ba_1
X_4545_ _0237_ _0241_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__nand2_1
X_7333_ _2989_ VGND VGND VPWR VPWR _2990_ sky130_fd_sc_hd__inv_2
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7264_ _2403_ _2919_ VGND VGND VPWR VPWR _2921_ sky130_fd_sc_hd__xnor2_1
X_4476_ _4283_ _4284_ VGND VGND VPWR VPWR _4285_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6215_ _1873_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7195_ _2798_ _2805_ _2812_ VGND VGND VPWR VPWR _2852_ sky130_fd_sc_hd__and3_1
X_6146_ _1794_ _1782_ _1801_ _1804_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__a211o_4
X_6077_ _0636_ _1630_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_56_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5028_ _0683_ _0624_ _0676_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_28_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6979_ _2613_ _2617_ _2622_ _2623_ VGND VGND VPWR VPWR _2636_ sky130_fd_sc_hd__a31oi_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8718_ clknet_4_7_0_clk _0092_ VGND VGND VPWR VPWR rf.registers\[25\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8649_ _4125_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6000_ _1582_ _1625_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7951_ _3596_ _3603_ VGND VGND VPWR VPWR _3604_ sky130_fd_sc_hd__nor2_1
X_6902_ _2548_ _2549_ _2529_ _2558_ _2526_ VGND VGND VPWR VPWR _2559_ sky130_fd_sc_hd__o2111ai_2
X_7882_ _3363_ _3534_ _3527_ VGND VGND VPWR VPWR _3535_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_53_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6833_ _2471_ _2478_ _2481_ _2460_ VGND VGND VPWR VPWR _2490_ sky130_fd_sc_hd__o31ai_1
XTAP_TAPCELL_ROW_25_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6764_ _2419_ _2420_ _0468_ _2409_ VGND VGND VPWR VPWR _2421_ sky130_fd_sc_hd__o2bb2a_2
X_6695_ _2155_ _2351_ VGND VGND VPWR VPWR _2352_ sky130_fd_sc_hd__xnor2_1
X_5715_ _1120_ _1256_ _1373_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_33_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8503_ net185 _4056_ VGND VGND VPWR VPWR _4064_ sky130_fd_sc_hd__and2_1
XFILLER_0_93_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5646_ _1303_ _1304_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8434_ net254 _0479_ _4019_ VGND VGND VPWR VPWR _4027_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5577_ net264 _1234_ _1235_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__nor3_1
X_8365_ _0813_ _3990_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__xnor2_1
X_8296_ _3633_ _3656_ _3658_ VGND VGND VPWR VPWR _3949_ sky130_fd_sc_hd__o21ai_1
X_4528_ _4202_ _0224_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__xnor2_1
X_7316_ net67 _2917_ VGND VGND VPWR VPWR _2973_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_92_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7247_ _2875_ _2879_ VGND VGND VPWR VPWR _2904_ sky130_fd_sc_hd__nor2_1
X_4459_ rf.registers\[25\]\[24\] _4166_ _4176_ rf.registers\[10\]\[24\] VGND VGND
+ VPWR VPWR _4268_ sky130_fd_sc_hd__a22o_1
X_7178_ _2820_ _2834_ VGND VGND VPWR VPWR _2835_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6129_ _0637_ _1773_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_5_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5500_ _1057_ _1059_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__and2_1
X_6480_ _2034_ _2132_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_30_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5431_ _1072_ _1077_ _1084_ _1085_ _1089_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__o311a_1
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8150_ _3624_ _3627_ VGND VGND VPWR VPWR _3803_ sky130_fd_sc_hd__nand2_1
X_5362_ _0924_ _1020_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__nor2_2
X_8081_ _2330_ _3733_ VGND VGND VPWR VPWR _3734_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_78_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7101_ _2716_ _2757_ _2740_ VGND VGND VPWR VPWR _2758_ sky130_fd_sc_hd__o21ai_1
X_5293_ _0618_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__buf_4
X_7032_ _2401_ _2670_ _2671_ VGND VGND VPWR VPWR _2689_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_66_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7934_ _3584_ _3586_ VGND VGND VPWR VPWR _3587_ sky130_fd_sc_hd__or2_1
X_7865_ _3516_ _3517_ VGND VGND VPWR VPWR _3518_ sky130_fd_sc_hd__and2_1
X_6816_ _2454_ _2456_ _2472_ _0505_ _2457_ VGND VGND VPWR VPWR _2473_ sky130_fd_sc_hd__a221o_1
XFILLER_0_9_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7796_ _3442_ _3445_ VGND VGND VPWR VPWR _3449_ sky130_fd_sc_hd__xnor2_1
X_6747_ _0694_ _2387_ VGND VGND VPWR VPWR _2404_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6678_ _2321_ _2334_ VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8417_ net259 _0544_ _4008_ VGND VGND VPWR VPWR _4018_ sky130_fd_sc_hd__mux2_1
X_5629_ _1216_ _1287_ _1196_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_103_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8348_ display.refresh_counter\[10\] display.refresh_counter\[11\] _3980_ VGND VGND
+ VPWR VPWR _3982_ sky130_fd_sc_hd__and3_1
X_8279_ _3644_ _3659_ VGND VGND VPWR VPWR _3932_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5980_ _1472_ _1569_ _1637_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__nand3_2
X_4931_ _0263_ _0251_ _0261_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__o31a_1
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7650_ _0587_ _3304_ VGND VGND VPWR VPWR _3305_ sky130_fd_sc_hd__xor2_2
XFILLER_0_74_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4862_ _4200_ _0486_ _0518_ _0488_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__o22a_1
X_6601_ _2256_ _2257_ _2258_ _2235_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__o211a_1
XFILLER_0_86_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4793_ _0238_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__buf_2
XFILLER_0_55_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7581_ _3231_ _3235_ VGND VGND VPWR VPWR _3236_ sky130_fd_sc_hd__xnor2_1
X_6532_ _2186_ _2189_ VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6463_ _2061_ _2121_ _2102_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__mux2_2
X_8202_ _3725_ VGND VGND VPWR VPWR _3855_ sky130_fd_sc_hd__inv_2
XFILLER_0_70_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5414_ _0990_ _0976_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8133_ _3782_ _3663_ _3785_ VGND VGND VPWR VPWR _3786_ sky130_fd_sc_hd__a21o_1
X_6394_ _0638_ _2045_ _2049_ _1679_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5345_ _0945_ _1003_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__xnor2_1
X_8064_ _2300_ _3716_ _2383_ VGND VGND VPWR VPWR _3717_ sky130_fd_sc_hd__mux2_2
XFILLER_0_10_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5276_ _0933_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__or2_1
X_7015_ _2670_ _2671_ VGND VGND VPWR VPWR _2672_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7917_ _3287_ _3569_ net3 VGND VGND VPWR VPWR _3570_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7848_ _3490_ _3500_ VGND VGND VPWR VPWR _3501_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7779_ _3420_ VGND VGND VPWR VPWR _3432_ sky130_fd_sc_hd__inv_2
XFILLER_0_92_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_612 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5130_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__buf_4
X_5061_ _0716_ _0692_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__and3_1
XFILLER_0_74_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8820_ clknet_4_10_0_clk _0194_ VGND VGND VPWR VPWR rf.registers\[5\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8751_ clknet_4_2_0_clk _0125_ VGND VGND VPWR VPWR rf.registers\[15\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_5963_ _1618_ _1621_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__xnor2_2
X_4914_ net39 _4156_ _0586_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__a21o_1
X_7702_ net66 _3354_ net2 VGND VGND VPWR VPWR _3355_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8682_ _4142_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
X_5894_ _1548_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__inv_2
XFILLER_0_74_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7633_ _2208_ _3287_ VGND VGND VPWR VPWR _3288_ sky130_fd_sc_hd__and2_1
X_4845_ _4200_ _0437_ _0441_ _0518_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__o221a_1
XFILLER_0_62_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4776_ _0358_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__buf_2
XFILLER_0_28_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7564_ _3218_ _3212_ _3216_ VGND VGND VPWR VPWR _3219_ sky130_fd_sc_hd__o21a_1
XFILLER_0_43_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6515_ _2013_ _2173_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7495_ _3140_ _3145_ VGND VGND VPWR VPWR _3150_ sky130_fd_sc_hd__nor2_1
X_6446_ _2084_ _2100_ _2101_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__and3b_1
XFILLER_0_70_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6377_ _2035_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__inv_2
X_8116_ _3661_ _3768_ VGND VGND VPWR VPWR _3769_ sky130_fd_sc_hd__or2_1
X_5328_ _0864_ _0961_ _0967_ _0627_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__a211o_1
X_8047_ _0587_ net7 VGND VGND VPWR VPWR _3700_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_89_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5259_ _0849_ _0917_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__and2b_1
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4630_ _4178_ _4243_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4561_ _0254_ _0257_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6300_ _1949_ _1836_ _1957_ _1958_ _0646_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__a32o_2
X_4492_ _4295_ _4300_ VGND VGND VPWR VPWR _4301_ sky130_fd_sc_hd__nand2_1
X_7280_ _2887_ _2908_ _2910_ VGND VGND VPWR VPWR _2937_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6231_ _1689_ _1740_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6162_ _1818_ _1820_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5113_ _0731_ _0771_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__xnor2_1
X_6093_ _1439_ _1747_ _1750_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__nand3_1
X_5044_ net24 _0624_ _0617_ _0695_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__o22a_1
XFILLER_0_79_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8803_ clknet_4_3_0_clk _0177_ VGND VGND VPWR VPWR rf.registers\[10\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6995_ _2649_ _2651_ VGND VGND VPWR VPWR _2652_ sky130_fd_sc_hd__nor2_1
X_8734_ clknet_4_9_0_clk _0108_ VGND VGND VPWR VPWR rf.registers\[15\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5946_ _1603_ _1604_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__xor2_1
X_5877_ _1436_ _1535_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__xnor2_1
X_8665_ net150 _4130_ VGND VGND VPWR VPWR _4134_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7616_ _3260_ _3270_ VGND VGND VPWR VPWR _3271_ sky130_fd_sc_hd__xnor2_1
Xclone16 _1692_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__buf_2
XFILLER_0_35_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4828_ _4273_ _4274_ _0311_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_105_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclone38 _1959_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_2
XFILLER_0_62_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8596_ _4097_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_105_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4759_ _0376_ _0408_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7547_ _3199_ _3196_ VGND VGND VPWR VPWR _3202_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7478_ _3132_ VGND VGND VPWR VPWR _3133_ sky130_fd_sc_hd__inv_2
XFILLER_0_43_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6429_ _2080_ _2081_ _2087_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__or3_1
XFILLER_0_70_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_556 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6780_ _2422_ _2428_ _2429_ _2432_ VGND VGND VPWR VPWR _2437_ sky130_fd_sc_hd__o31ai_4
X_5800_ _1457_ _1458_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5731_ _1381_ _1382_ _1389_ _1385_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__o211a_1
XFILLER_0_57_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8450_ _4036_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5662_ _1021_ _1314_ _1211_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__o21ba_1
X_8381_ _3999_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_7401_ _3015_ _3031_ _3057_ VGND VGND VPWR VPWR _3058_ sky130_fd_sc_hd__o21a_1
XFILLER_0_60_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5593_ _1163_ _1251_ _1221_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__mux2_4
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4613_ _4281_ _0308_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__a21oi_1
X_4544_ _0240_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__inv_2
X_7332_ _2394_ _2988_ VGND VGND VPWR VPWR _2989_ sky130_fd_sc_hd__xnor2_1
X_7263_ _2917_ _2919_ VGND VGND VPWR VPWR _2920_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6214_ _1724_ _1872_ _1822_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__mux2_2
X_4475_ _4224_ _4225_ _4261_ VGND VGND VPWR VPWR _4284_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_0_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7194_ _2798_ _2843_ VGND VGND VPWR VPWR _2851_ sky130_fd_sc_hd__nor2_1
X_6145_ _1766_ _1803_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6076_ _1602_ _1608_ _1734_ _1609_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__a211o_1
X_5027_ net33 _0625_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_56_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6978_ _2389_ _2607_ VGND VGND VPWR VPWR _2635_ sky130_fd_sc_hd__and2_1
X_8717_ clknet_4_7_0_clk _0091_ VGND VGND VPWR VPWR rf.registers\[25\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5929_ _1584_ _1587_ _1569_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8648_ net188 _4119_ VGND VGND VPWR VPWR _4125_ sky130_fd_sc_hd__and2_1
X_8579_ _4088_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7950_ _3602_ _3599_ _3593_ VGND VGND VPWR VPWR _3603_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_19_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6901_ _2556_ VGND VGND VPWR VPWR _2558_ sky130_fd_sc_hd__clkbuf_4
X_7881_ _3528_ _3532_ _3530_ VGND VGND VPWR VPWR _3534_ sky130_fd_sc_hd__a21o_1
X_6832_ _2488_ VGND VGND VPWR VPWR _2489_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_53_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6763_ _2415_ _2412_ _2411_ VGND VGND VPWR VPWR _2420_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6694_ _2148_ _2219_ _2350_ VGND VGND VPWR VPWR _2351_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_61_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5714_ _1257_ _1264_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__and2b_1
X_8502_ _4063_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5645_ _0650_ _1302_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_28_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8433_ _4026_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5576_ _1142_ _1231_ _1233_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__and3_1
XFILLER_0_25_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8364_ _3992_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
X_8295_ _3632_ _3659_ VGND VGND VPWR VPWR _3948_ sky130_fd_sc_hd__or2b_1
X_4527_ _4163_ _4201_ _4203_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__a21oi_1
X_7315_ _2946_ _2971_ _2969_ VGND VGND VPWR VPWR _2972_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7246_ _2890_ _2899_ _2901_ _2902_ VGND VGND VPWR VPWR _2903_ sky130_fd_sc_hd__nor4_1
XFILLER_0_13_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4458_ _4260_ _4265_ VGND VGND VPWR VPWR _4267_ sky130_fd_sc_hd__and2_1
X_7177_ _2826_ _2829_ _2830_ _2832_ _2833_ VGND VGND VPWR VPWR _2834_ sky130_fd_sc_hd__o311a_1
X_4389_ _4154_ _4169_ _4197_ VGND VGND VPWR VPWR _4198_ sky130_fd_sc_hd__and3_1
X_6128_ _1679_ _1786_ _1768_ _1766_ _1779_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_37_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6059_ _1710_ _1716_ _1717_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__and3_2
XFILLER_0_68_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_55_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5430_ _1086_ _1088_ _1032_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5361_ _0932_ _1019_ net75 VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__mux2_2
X_8080_ _2312_ _2363_ _2368_ VGND VGND VPWR VPWR _3733_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_78_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_73_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5292_ net19 _0950_ _0940_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__mux2_4
X_7100_ _2723_ _2734_ VGND VGND VPWR VPWR _2757_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7031_ _2683_ _2685_ _2686_ _2687_ VGND VGND VPWR VPWR _2688_ sky130_fd_sc_hd__or4_1
X_7933_ _3578_ _3585_ VGND VGND VPWR VPWR _3586_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_66_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7864_ _3369_ _3515_ VGND VGND VPWR VPWR _3517_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6815_ _0494_ _2387_ VGND VGND VPWR VPWR _2472_ sky130_fd_sc_hd__nand2_1
X_7795_ net23 _3447_ _3333_ VGND VGND VPWR VPWR _3448_ sky130_fd_sc_hd__mux2_1
X_6746_ _2402_ VGND VGND VPWR VPWR _2403_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6677_ _2325_ _2330_ _2333_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__or3b_1
XFILLER_0_33_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8416_ _4017_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
X_5628_ _1184_ _1191_ _1192_ _1125_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__o211ai_1
X_5559_ _1215_ _1191_ _1217_ _1118_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__a211o_1
X_8347_ net136 _3980_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__xor2_1
XFILLER_0_41_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8278_ _3898_ _3854_ _3918_ _3930_ VGND VGND VPWR VPWR _3931_ sky130_fd_sc_hd__a31oi_1
X_7229_ _2855_ _2883_ _2884_ _2885_ VGND VGND VPWR VPWR _2886_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_96_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4930_ _0390_ _0264_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_63_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4861_ _4150_ _0485_ _0490_ _0358_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a31o_1
X_6600_ _2157_ _2241_ _2244_ _2248_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4792_ _0383_ _0420_ _0483_ _0445_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_15_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7580_ _0556_ _3227_ VGND VGND VPWR VPWR _3235_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6531_ _2186_ _2189_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__or2_1
XFILLER_0_70_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6462_ _2062_ _2120_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__xor2_1
XFILLER_0_70_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8201_ _3821_ _3837_ _3852_ _3853_ VGND VGND VPWR VPWR _3854_ sky130_fd_sc_hd__and4b_1
X_6393_ _0638_ _2045_ VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__nand2_1
X_5413_ _1066_ _1032_ _1071_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__o21a_1
X_8132_ _3783_ _3784_ _2384_ VGND VGND VPWR VPWR _3785_ sky130_fd_sc_hd__mux2_2
X_5344_ _0948_ _1002_ _0634_ _0947_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_2_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8063_ _2301_ _3711_ VGND VGND VPWR VPWR _3716_ sky130_fd_sc_hd__xnor2_1
X_5275_ _0653_ _0932_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__nor2_1
X_7014_ _2644_ _2646_ _2648_ _2668_ VGND VGND VPWR VPWR _2671_ sky130_fd_sc_hd__nand4_1
XFILLER_0_37_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7916_ _1723_ _2968_ _3119_ VGND VGND VPWR VPWR _3569_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7847_ _3493_ _3499_ VGND VGND VPWR VPWR _3500_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7778_ _3430_ VGND VGND VPWR VPWR _3431_ sky130_fd_sc_hd__inv_2
X_6729_ _2385_ VGND VGND VPWR VPWR _2386_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_104_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5060_ _0625_ _0715_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__o21a_1
XFILLER_0_79_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8750_ clknet_4_2_0_clk _0124_ VGND VGND VPWR VPWR rf.registers\[15\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_5962_ _1512_ _1620_ _1568_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__mux2_4
X_4913_ _0355_ net57 _0585_ _4158_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__a22o_1
X_7701_ _3265_ _3353_ net3 VGND VGND VPWR VPWR _3354_ sky130_fd_sc_hd__mux2_1
X_8681_ net154 _4107_ VGND VGND VPWR VPWR _4142_ sky130_fd_sc_hd__and2_1
X_5893_ _1547_ _1546_ _1551_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__a21o_1
X_7632_ _3283_ _3285_ _3286_ VGND VGND VPWR VPWR _3287_ sky130_fd_sc_hd__o21ai_1
X_4844_ _4150_ _0485_ _0444_ _0357_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__a31o_1
XFILLER_0_47_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4775_ net29 VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__buf_2
X_7563_ _3210_ VGND VGND VPWR VPWR _3218_ sky130_fd_sc_hd__inv_2
X_6514_ net87 _2095_ _2163_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__o21a_1
XFILLER_0_55_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_532 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7494_ _0494_ _3148_ VGND VGND VPWR VPWR _3149_ sky130_fd_sc_hd__or2_1
X_6445_ _2103_ _2087_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__nand2_1
X_6376_ _1917_ _1921_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8115_ _2319_ _3767_ _2333_ VGND VGND VPWR VPWR _3768_ sky130_fd_sc_hd__a21oi_1
X_5327_ _0981_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__and2b_1
X_8046_ _0587_ _3698_ net96 VGND VGND VPWR VPWR _3699_ sky130_fd_sc_hd__mux2_4
XTAP_TAPCELL_ROW_89_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5258_ _0916_ _0848_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__or2_1
X_5189_ _0633_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4560_ _0252_ _0253_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4491_ _4214_ _4294_ _4219_ VGND VGND VPWR VPWR _4300_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_52_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6230_ _1676_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__buf_4
XFILLER_0_40_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6161_ _1682_ _1691_ _1688_ _1819_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__a31o_1
XFILLER_0_85_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5112_ _0690_ _0730_ _0736_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6092_ _1747_ _1750_ _1439_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_18_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5043_ _0695_ _0617_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__nand2_1
X_8802_ clknet_4_3_0_clk _0176_ VGND VGND VPWR VPWR rf.registers\[10\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_84_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6994_ _2650_ _2632_ VGND VGND VPWR VPWR _2651_ sky130_fd_sc_hd__and2b_1
XFILLER_0_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8733_ clknet_4_8_0_clk _0107_ VGND VGND VPWR VPWR rf.registers\[15\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_5945_ _1499_ _1483_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5876_ _1534_ _1432_ _1440_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__o21ai_1
X_8664_ _4133_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7615_ _0573_ _3265_ VGND VGND VPWR VPWR _3270_ sky130_fd_sc_hd__or2b_1
X_4827_ _4273_ _4274_ _0311_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__or3_1
XFILLER_0_105_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8595_ rf.registers\[10\]\[22\] _4094_ VGND VGND VPWR VPWR _4097_ sky130_fd_sc_hd__and2_1
X_4758_ _0376_ _0419_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__nor2_1
X_7546_ net20 _3200_ _3195_ VGND VGND VPWR VPWR _3201_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_50_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4689_ _4193_ _0356_ _0358_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__a22o_1
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7477_ _0468_ _3131_ VGND VGND VPWR VPWR _3132_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_95_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6428_ _2085_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6359_ _1960_ net114 _2017_ _1860_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__a211o_1
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8029_ _2254_ _2261_ _2284_ VGND VGND VPWR VPWR _3682_ sky130_fd_sc_hd__o21a_1
XFILLER_0_98_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5730_ _1374_ _1388_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__xor2_1
XFILLER_0_72_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7400_ _3016_ _3028_ _3030_ VGND VGND VPWR VPWR _3057_ sky130_fd_sc_hd__a21o_1
X_5661_ _1027_ _1033_ _1134_ _1231_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__or4_1
X_8380_ net204 _0607_ _3997_ VGND VGND VPWR VPWR _3999_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5592_ _1250_ _1170_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
X_4612_ _4275_ _4277_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__xnor2_1
X_4543_ _4194_ _0239_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__xor2_1
X_7331_ _2960_ _2987_ VGND VGND VPWR VPWR _2988_ sky130_fd_sc_hd__xor2_2
XFILLER_0_13_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7262_ _2901_ _2918_ VGND VGND VPWR VPWR _2919_ sky130_fd_sc_hd__xor2_1
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6213_ _1869_ _1871_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4474_ rf.registers\[25\]\[20\] _4166_ _4175_ rf.registers\[10\]\[20\] VGND VGND
+ VPWR VPWR _4283_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7193_ _2392_ _2819_ _2820_ _2834_ VGND VGND VPWR VPWR _2850_ sky130_fd_sc_hd__a2bb2o_1
X_6144_ _1581_ _1802_ _1723_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__mux2_1
X_6075_ _0645_ _1640_ _1643_ _1645_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__a211o_1
X_5026_ _0656_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6977_ net20 _2400_ VGND VGND VPWR VPWR _2634_ sky130_fd_sc_hd__nand2_1
X_8716_ clknet_4_6_0_clk _0090_ VGND VGND VPWR VPWR rf.registers\[25\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_5928_ _1496_ _1585_ _1586_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8647_ _4124_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
X_5859_ _1517_ _1516_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__or2_4
X_8578_ net177 _4083_ VGND VGND VPWR VPWR _4088_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7529_ net62 _3183_ VGND VGND VPWR VPWR _3184_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7880_ _3531_ _3528_ _3532_ VGND VGND VPWR VPWR _3533_ sky130_fd_sc_hd__mux2_1
X_6900_ _2526_ _2529_ _2556_ _2549_ _2548_ VGND VGND VPWR VPWR _2557_ sky130_fd_sc_hd__a311o_1
XFILLER_0_106_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6831_ _2486_ _2483_ _2487_ VGND VGND VPWR VPWR _2488_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_53_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6762_ _2418_ _2414_ VGND VGND VPWR VPWR _2419_ sky130_fd_sc_hd__and2_1
X_8501_ net174 _4056_ VGND VGND VPWR VPWR _4063_ sky130_fd_sc_hd__and2_1
X_6693_ _0639_ _2147_ VGND VGND VPWR VPWR _2350_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_61_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5713_ _1333_ _1325_ net264 VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__a21o_4
XTAP_TAPCELL_ROW_33_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5644_ _0650_ _1302_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__nand2_1
X_8432_ net213 _0493_ _4019_ VGND VGND VPWR VPWR _4026_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8363_ _3990_ _3991_ VGND VGND VPWR VPWR _3992_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7314_ _1843_ _2393_ _2968_ VGND VGND VPWR VPWR _2971_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_13_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5575_ _1231_ _1233_ _1142_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__a21oi_1
X_8294_ _3648_ _3933_ VGND VGND VPWR VPWR _3947_ sky130_fd_sc_hd__xnor2_1
X_4526_ _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_92_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7245_ _2870_ _2896_ VGND VGND VPWR VPWR _2902_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4457_ _4260_ _4265_ VGND VGND VPWR VPWR _4266_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7176_ _2790_ _2829_ VGND VGND VPWR VPWR _2833_ sky130_fd_sc_hd__xnor2_1
X_4388_ imem.address\[2\] _4162_ VGND VGND VPWR VPWR _4197_ sky130_fd_sc_hd__xnor2_1
X_6127_ _1651_ _1763_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_69_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6058_ _1712_ _1715_ _1582_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__o21ai_1
X_5009_ _0616_ _0622_ _0667_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_68_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5360_ _0935_ _1018_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_78_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5291_ _0877_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__nand2_1
X_7030_ _2644_ _2668_ _2646_ VGND VGND VPWR VPWR _2687_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7932_ _3577_ _3571_ VGND VGND VPWR VPWR _3585_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_66_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7863_ _3369_ _3515_ VGND VGND VPWR VPWR _3516_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6814_ _2387_ _2470_ VGND VGND VPWR VPWR _2471_ sky130_fd_sc_hd__xnor2_1
X_7794_ _3338_ _3176_ _2489_ _3118_ VGND VGND VPWR VPWR _3447_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_73_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6745_ _2401_ VGND VGND VPWR VPWR _2402_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_73_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6676_ _2117_ _2332_ _2296_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__mux2_1
X_8415_ rf.registers\[25\]\[18\] _0549_ _4008_ VGND VGND VPWR VPWR _4017_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5627_ _1277_ _1265_ _1279_ _1284_ _1285_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_33_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5558_ _0660_ _1117_ _1216_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__o21ba_1
X_8346_ _3980_ _3981_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__nor2_1
X_8277_ _3928_ _3929_ _3348_ VGND VGND VPWR VPWR _3930_ sky130_fd_sc_hd__o21ai_1
X_4509_ _4212_ _4317_ VGND VGND VPWR VPWR _4318_ sky130_fd_sc_hd__xor2_2
XFILLER_0_41_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7228_ _2860_ _2880_ VGND VGND VPWR VPWR _2885_ sky130_fd_sc_hd__nor2_1
X_5489_ _1012_ _1050_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__or2_1
X_7159_ _2798_ _2805_ _2812_ _2815_ VGND VGND VPWR VPWR _2816_ sky130_fd_sc_hd__a31o_2
XFILLER_0_95_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_1_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4860_ net20 _0527_ _0544_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6530_ net7 _2187_ _2188_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__a21bo_1
X_4791_ _0383_ _0411_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6461_ _1689_ _2064_ _2119_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_70_555 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8200_ _3709_ _3820_ VGND VGND VPWR VPWR _3853_ sky130_fd_sc_hd__or2_1
X_6392_ _2029_ _2026_ _2047_ _2050_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__a211o_1
X_5412_ _0872_ _1070_ _1031_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__or3_4
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8131_ net109 _2376_ _2378_ VGND VGND VPWR VPWR _3784_ sky130_fd_sc_hd__o21ba_1
X_5343_ _0992_ _1000_ _1001_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8062_ _2304_ _3714_ _2383_ VGND VGND VPWR VPWR _3715_ sky130_fd_sc_hd__mux2_4
X_5274_ _0653_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__and2_1
X_7013_ _2644_ _2646_ _2668_ _2648_ VGND VGND VPWR VPWR _2670_ sky130_fd_sc_hd__a31o_1
XFILLER_0_78_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7915_ _3352_ _3561_ _3563_ _3567_ VGND VGND VPWR VPWR _3568_ sky130_fd_sc_hd__a31o_1
X_7846_ _3494_ _3496_ _3498_ VGND VGND VPWR VPWR _3499_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_65_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4989_ _0616_ _0622_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__nand2_4
XFILLER_0_18_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7777_ _3383_ _3429_ VGND VGND VPWR VPWR _3430_ sky130_fd_sc_hd__or2_1
XFILLER_0_80_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6728_ net110 _0614_ net91 VGND VGND VPWR VPWR _2385_ sky130_fd_sc_hd__and3b_1
XFILLER_0_104_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6659_ _2313_ _2315_ _2115_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8329_ _3970_ net120 VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5961_ _1513_ _1619_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4912_ _0275_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7700_ _1335_ _2883_ _3119_ VGND VGND VPWR VPWR _3353_ sky130_fd_sc_hd__mux2_1
X_8680_ _4141_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
X_7631_ _3277_ _3267_ _3279_ VGND VGND VPWR VPWR _3286_ sky130_fd_sc_hd__mux2_1
X_5892_ _1484_ _1550_ _1329_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_90_606 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4843_ _0528_ _4282_ _0307_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_23_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7562_ _3210_ _3213_ _3216_ VGND VGND VPWR VPWR _3217_ sky130_fd_sc_hd__mux2_1
X_4774_ net61 _4157_ _0467_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__a21o_1
X_6513_ _2071_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__buf_4
XFILLER_0_82_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7493_ _0480_ _3145_ VGND VGND VPWR VPWR _3148_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6444_ _1980_ _2070_ _2076_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__a21o_1
XFILLER_0_101_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6375_ _1865_ _2033_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__xnor2_1
X_8114_ _2321_ _2325_ _3737_ _2384_ VGND VGND VPWR VPWR _3767_ sky130_fd_sc_hd__o31a_1
XFILLER_0_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5326_ _0906_ _0983_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__or3_4
X_8045_ _2253_ _3697_ VGND VGND VPWR VPWR _3698_ sky130_fd_sc_hd__nand2_1
X_5257_ _0792_ _0844_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_89_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5188_ _0779_ _0789_ _0845_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire50 _3857_ VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7829_ _3377_ _3481_ VGND VGND VPWR VPWR _3482_ sky130_fd_sc_hd__and2b_1
XFILLER_0_81_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4490_ rf.registers\[25\]\[16\] _4165_ _4174_ rf.registers\[10\]\[16\] VGND VGND
+ VPWR VPWR _4299_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6160_ _1690_ _1700_ net83 VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_20_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5111_ _0684_ net101 VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__nor2_4
X_6091_ net83 _1700_ _1749_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__a21o_1
X_5042_ _0699_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__nor2_1
X_8801_ clknet_4_9_0_clk _0175_ VGND VGND VPWR VPWR rf.registers\[10\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_6993_ _2629_ _2630_ _2389_ VGND VGND VPWR VPWR _2650_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_87_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8732_ clknet_4_8_0_clk _0106_ VGND VGND VPWR VPWR rf.registers\[15\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5944_ _1491_ _1498_ _1500_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__o21ai_1
X_5875_ _1356_ _1401_ _1421_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__and3_1
X_8663_ net186 _4130_ VGND VGND VPWR VPWR _4133_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7614_ net66 _3266_ VGND VGND VPWR VPWR _3269_ sky130_fd_sc_hd__or2_1
X_4826_ net25 VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__clkbuf_4
X_8594_ _4096_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7545_ _3193_ _3197_ _3199_ VGND VGND VPWR VPWR _3200_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4757_ _0422_ _0417_ _0367_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__mux2_1
X_4688_ _0370_ _0384_ _0238_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__mux2_1
X_7476_ net61 _3125_ _3127_ _3129_ VGND VGND VPWR VPWR _3131_ sky130_fd_sc_hd__a31o_1
XFILLER_0_101_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6427_ _0647_ _2084_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__nand2_1
X_6358_ _2005_ _2006_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__nor2_1
X_5309_ _0864_ _0961_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__a21o_1
X_6289_ _1947_ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__inv_2
X_8028_ _3667_ _2279_ VGND VGND VPWR VPWR _3681_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_104_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5660_ _1309_ _1317_ _1318_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__nor3_1
XFILLER_0_45_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4611_ _4282_ _0307_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5591_ _1172_ _1164_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__or2b_1
X_4542_ _0238_ _0232_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__nand2_1
X_7330_ _2961_ _2986_ VGND VGND VPWR VPWR _2987_ sky130_fd_sc_hd__nor2_1
X_7261_ _2899_ _2902_ _2911_ VGND VGND VPWR VPWR _2918_ sky130_fd_sc_hd__or3_1
X_4473_ _4278_ _4280_ VGND VGND VPWR VPWR _4282_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6212_ _1725_ _1870_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7192_ _2392_ _2848_ VGND VGND VPWR VPWR _2849_ sky130_fd_sc_hd__nand2_1
X_6143_ _1663_ _1666_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__xnor2_1
X_6074_ _1648_ _1653_ _1655_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__a21bo_1
X_5025_ _0683_ net89 VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__or2_2
X_6976_ _0807_ _2389_ VGND VGND VPWR VPWR _2633_ sky130_fd_sc_hd__nand2_1
X_8715_ clknet_4_4_0_clk _0089_ VGND VGND VPWR VPWR rf.registers\[25\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5927_ _1492_ _0636_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8646_ net142 _4119_ VGND VGND VPWR VPWR _4124_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5858_ _1121_ _1515_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__and2_4
XFILLER_0_90_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4809_ _0440_ _0442_ _0369_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__mux2_1
X_8577_ _4087_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5789_ _1308_ _1447_ _1335_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7528_ _3178_ _3180_ _3182_ VGND VGND VPWR VPWR _3183_ sky130_fd_sc_hd__a21oi_1
X_7459_ _3082_ _3093_ VGND VGND VPWR VPWR _3115_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6830_ _2398_ _2455_ _2430_ _2457_ VGND VGND VPWR VPWR _2487_ sky130_fd_sc_hd__or4b_1
XFILLER_0_106_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6761_ _0468_ _2409_ _2413_ VGND VGND VPWR VPWR _2418_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5712_ _1369_ _1370_ _1121_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__a21oi_2
X_8500_ _4062_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__clkbuf_1
X_6692_ _2348_ VGND VGND VPWR VPWR _2349_ sky130_fd_sc_hd__inv_2
XFILLER_0_85_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5643_ _1182_ _1301_ net68 VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8431_ _4025_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
X_5574_ _1120_ _1232_ _1226_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__a21oi_1
X_8362_ display.refresh_counter\[16\] _3988_ VGND VGND VPWR VPWR _3991_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4525_ rf.registers\[25\]\[7\] _4164_ _4172_ rf.registers\[10\]\[7\] VGND VGND VPWR
+ VPWR _0222_ sky130_fd_sc_hd__a22o_1
X_7313_ _2944_ _2969_ VGND VGND VPWR VPWR _2970_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8293_ _2396_ _3938_ _3940_ _3945_ VGND VGND VPWR VPWR _3946_ sky130_fd_sc_hd__a211o_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7244_ _2888_ _2900_ VGND VGND VPWR VPWR _2901_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4456_ _4179_ _4233_ _4264_ VGND VGND VPWR VPWR _4265_ sky130_fd_sc_hd__and3_1
X_4387_ rf.registers\[5\]\[3\] rf.registers\[15\]\[3\] _4171_ VGND VGND VPWR VPWR
+ _4196_ sky130_fd_sc_hd__mux2_2
X_7175_ _2817_ _2831_ VGND VGND VPWR VPWR _2832_ sky130_fd_sc_hd__nor2_1
X_6126_ _0637_ _1773_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6057_ _1582_ _1712_ _1715_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__or3_1
X_5008_ net26 VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6959_ _2614_ _2615_ VGND VGND VPWR VPWR _2616_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_101_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8629_ net170 _4108_ VGND VGND VPWR VPWR _4115_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5290_ net19 _0627_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7931_ _0587_ _3342_ _3582_ _3583_ VGND VGND VPWR VPWR _3584_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7862_ _3512_ _3514_ VGND VGND VPWR VPWR _3515_ sky130_fd_sc_hd__nand2_1
X_6813_ _2462_ _2468_ _2469_ _2452_ VGND VGND VPWR VPWR _2470_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_9_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7793_ _3381_ _3439_ _3441_ _3445_ VGND VGND VPWR VPWR _3446_ sky130_fd_sc_hd__a31o_1
XFILLER_0_85_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6744_ _2400_ VGND VGND VPWR VPWR _2401_ sky130_fd_sc_hd__buf_2
X_6675_ _2118_ _2331_ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8414_ _4016_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
X_5626_ _1236_ _1230_ _1237_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__or3_1
XFILLER_0_103_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5557_ _0971_ _1124_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__or2_1
X_8345_ net126 _3978_ VGND VGND VPWR VPWR _3981_ sky130_fd_sc_hd__nor2_1
X_8276_ _3663_ _3782_ _3848_ _3772_ VGND VGND VPWR VPWR _3929_ sky130_fd_sc_hd__a22o_1
X_4508_ _4210_ _4311_ VGND VGND VPWR VPWR _4317_ sky130_fd_sc_hd__nor2_1
X_5488_ _1055_ _1060_ _1064_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7227_ _2860_ _2880_ _2883_ VGND VGND VPWR VPWR _2884_ sky130_fd_sc_hd__a21bo_1
Xwire2 _2809_ VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__clkbuf_1
X_4439_ rf.registers\[25\]\[28\] _4167_ _4177_ rf.registers\[10\]\[28\] VGND VGND
+ VPWR VPWR _4248_ sky130_fd_sc_hd__a22o_1
X_7158_ _2814_ VGND VGND VPWR VPWR _2815_ sky130_fd_sc_hd__inv_2
X_6109_ _1767_ _1645_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__xnor2_4
X_7089_ _2744_ _2745_ VGND VGND VPWR VPWR _2746_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_1_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_102_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4790_ _0318_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6460_ _2051_ _2057_ _2065_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__a21oi_1
X_6391_ _1679_ _2049_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5411_ _0969_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8130_ _2375_ VGND VGND VPWR VPWR _3783_ sky130_fd_sc_hd__clkinvlp_2
X_5342_ _0996_ _0993_ _0997_ _0643_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__o211a_1
XFILLER_0_23_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8061_ _2307_ _3713_ VGND VGND VPWR VPWR _3714_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5273_ _0838_ _0931_ _0856_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__mux2_1
X_7012_ _2631_ _2653_ _2668_ VGND VGND VPWR VPWR _2669_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7914_ _3352_ _3566_ VGND VGND VPWR VPWR _3567_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7845_ _3486_ _3497_ VGND VGND VPWR VPWR _3498_ sky130_fd_sc_hd__nor2_1
X_4988_ _0646_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__buf_4
XFILLER_0_18_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7776_ _3385_ _3420_ _3423_ _3428_ VGND VGND VPWR VPWR _3429_ sky130_fd_sc_hd__a31o_1
XFILLER_0_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6727_ net96 VGND VGND VPWR VPWR _2384_ sky130_fd_sc_hd__buf_6
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6658_ _2128_ _2314_ _2222_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_104_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5609_ _1012_ _1266_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6589_ _2111_ _2245_ _2246_ _2247_ VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__o31a_1
XFILLER_0_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8328_ net115 display.refresh_counter\[1\] net119 VGND VGND VPWR VPWR _3971_ sky130_fd_sc_hd__a21oi_1
X_8259_ _0595_ net6 net7 _0591_ VGND VGND VPWR VPWR _3912_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_69_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_75_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5960_ _1611_ _1614_ _1516_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_86_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4911_ _0274_ _0230_ _0272_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__and3_1
X_5891_ _1341_ _1549_ _1533_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__mux2_1
X_7630_ _3284_ VGND VGND VPWR VPWR _3285_ sky130_fd_sc_hd__inv_2
XFILLER_0_47_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4842_ _0528_ _0308_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__or2_1
XFILLER_0_90_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7561_ _3215_ _3205_ _3203_ VGND VGND VPWR VPWR _3216_ sky130_fd_sc_hd__mux2_1
X_4773_ _4158_ _0450_ _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6512_ _2010_ _2170_ _2102_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7492_ _3140_ _3142_ _3146_ VGND VGND VPWR VPWR _3147_ sky130_fd_sc_hd__a21o_1
X_6443_ _2100_ _2101_ VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__nand2_2
XFILLER_0_43_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6374_ _1912_ _2032_ _1961_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8113_ _3748_ _3753_ _3758_ _3765_ VGND VGND VPWR VPWR _3766_ sky130_fd_sc_hd__nor4_1
X_5325_ _0982_ _0941_ _0890_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8044_ _0587_ net6 VGND VGND VPWR VPWR _3697_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5256_ _0911_ _0893_ _0912_ _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__a31o_4
X_5187_ _0776_ _0789_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7828_ _3480_ _3476_ _3473_ VGND VGND VPWR VPWR _3481_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_93_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7759_ _3331_ _2409_ _3145_ _3337_ VGND VGND VPWR VPWR _3412_ sky130_fd_sc_hd__o22a_1
XFILLER_0_73_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6090_ _1626_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__xnor2_1
X_5110_ _0743_ _0767_ _0764_ _0762_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__o41a_1
X_5041_ _0616_ _0698_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__nor2_1
X_8800_ clknet_4_9_0_clk _0174_ VGND VGND VPWR VPWR rf.registers\[10\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_8731_ clknet_4_8_0_clk _0105_ VGND VGND VPWR VPWR rf.registers\[15\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_6992_ _2644_ _2646_ _2648_ VGND VGND VPWR VPWR _2649_ sky130_fd_sc_hd__and3_1
X_5943_ _1596_ _1589_ _1600_ _1601_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__a211o_4
X_8662_ _4132_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
X_5874_ _1456_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__buf_4
X_7613_ _3251_ _3262_ VGND VGND VPWR VPWR _3268_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4825_ _0505_ _4157_ _0514_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__a21o_1
X_8593_ net161 _4094_ VGND VGND VPWR VPWR _4096_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7544_ _3190_ _3198_ VGND VGND VPWR VPWR _3199_ sky130_fd_sc_hd__nor2_1
X_4756_ _0322_ _0449_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__nor2_1
X_4687_ _0377_ _0381_ _0383_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7475_ _3123_ _3129_ VGND VGND VPWR VPWR _3130_ sky130_fd_sc_hd__xnor2_1
X_6426_ _0647_ _2084_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__or2_1
XFILLER_0_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6357_ _1853_ _1855_ net114 _1960_ VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__o211ai_1
X_5308_ _0962_ _0963_ _0966_ _0655_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__o211a_1
X_6288_ _1835_ _1946_ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__nor2_1
X_8027_ _3679_ VGND VGND VPWR VPWR _3680_ sky130_fd_sc_hd__inv_2
X_5239_ _0894_ _0827_ _0829_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__o21ai_1
Xclone1 _1220_ _1214_ net264 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__a21oi_2
XFILLER_0_66_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4610_ _4283_ _4284_ _0306_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5590_ _1230_ _1238_ _1245_ _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__o31a_1
X_4541_ _4195_ _4196_ _4198_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7260_ _2403_ VGND VGND VPWR VPWR _2917_ sky130_fd_sc_hd__buf_2
X_4472_ _4278_ _4280_ VGND VGND VPWR VPWR _4281_ sky130_fd_sc_hd__nand2_1
X_6211_ _0637_ _1724_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__nand2_1
X_7191_ _2838_ _2847_ _2816_ VGND VGND VPWR VPWR _2848_ sky130_fd_sc_hd__mux2_1
X_6142_ _1799_ _1800_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6073_ _0637_ _1724_ _1731_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5024_ net34 VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6975_ _2389_ _2629_ _2630_ VGND VGND VPWR VPWR _2632_ sky130_fd_sc_hd__nand3_2
X_8714_ clknet_4_4_0_clk _0088_ VGND VGND VPWR VPWR rf.registers\[25\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_5926_ _0620_ _1584_ _1497_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8645_ _4123_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_618 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5857_ _1484_ _1515_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8576_ net247 _4083_ VGND VGND VPWR VPWR _4087_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_331 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5788_ _1309_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__xor2_1
X_4808_ _0315_ _0498_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__xnor2_1
X_4739_ _0431_ _0433_ _0344_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7527_ _3181_ _3172_ _3175_ VGND VGND VPWR VPWR _3182_ sky130_fd_sc_hd__mux2_1
X_7458_ _3078_ _3083_ _3087_ VGND VGND VPWR VPWR _3114_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6409_ _1889_ _1979_ VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__or2_1
X_7389_ _3018_ _3033_ VGND VGND VPWR VPWR _3046_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xsplit43 display.refresh_counter\[19\] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__buf_1
XFILLER_0_54_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6760_ _2410_ _2416_ VGND VGND VPWR VPWR _2417_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5711_ _1334_ _1283_ _1368_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__nand3_4
XFILLER_0_85_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6691_ _2149_ _2152_ VGND VGND VPWR VPWR _2348_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_61_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5642_ _1195_ _1183_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__xnor2_1
X_8430_ net253 _0504_ _4019_ VGND VGND VPWR VPWR _4025_ sky130_fd_sc_hd__mux2_1
X_5573_ _1175_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__inv_2
X_8361_ net244 _3988_ VGND VGND VPWR VPWR _3990_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4524_ _4330_ _4332_ VGND VGND VPWR VPWR _4333_ sky130_fd_sc_hd__nand2_1
X_7312_ _2948_ _2968_ VGND VGND VPWR VPWR _2969_ sky130_fd_sc_hd__and2b_1
XFILLER_0_25_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8292_ _3643_ _3944_ _3659_ _3641_ VGND VGND VPWR VPWR _3945_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_13_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7243_ _2874_ net53 _2876_ VGND VGND VPWR VPWR _2900_ sky130_fd_sc_hd__a21oi_1
X_4455_ _4231_ _4263_ VGND VGND VPWR VPWR _4264_ sky130_fd_sc_hd__nand2_1
X_4386_ _4147_ _4171_ VGND VGND VPWR VPWR _4195_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7174_ _2791_ _2816_ _2794_ VGND VGND VPWR VPWR _2831_ sky130_fd_sc_hd__a21oi_1
X_6125_ _0646_ _1764_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_69_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6056_ _1699_ _1700_ _1714_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__a21oi_1
X_5007_ net24 _0658_ _0622_ net25 VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_52_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6958_ _2589_ _2592_ _2609_ VGND VGND VPWR VPWR _2615_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_101_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6889_ _2537_ _2524_ VGND VGND VPWR VPWR _2546_ sky130_fd_sc_hd__nand2_1
X_5909_ _1565_ _1566_ _1567_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__a21oi_4
X_8628_ _4114_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8559_ net207 _4072_ VGND VGND VPWR VPWR _4078_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7930_ _3329_ _3296_ _3342_ VGND VGND VPWR VPWR _3583_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_66_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7861_ _3504_ _3513_ _3506_ VGND VGND VPWR VPWR _3514_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6812_ _2454_ _2456_ _2457_ _2461_ _2467_ VGND VGND VPWR VPWR _2469_ sky130_fd_sc_hd__a2111o_1
X_7792_ _3381_ _3444_ VGND VGND VPWR VPWR _3445_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6743_ _2399_ VGND VGND VPWR VPWR _2400_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6674_ _2115_ _2313_ _2315_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__or3_1
XFILLER_0_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8413_ rf.registers\[25\]\[17\] _0555_ _4008_ VGND VGND VPWR VPWR _4016_ sky130_fd_sc_hd__mux2_1
X_5625_ _0629_ _1274_ _1283_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5556_ _1196_ _1125_ _1192_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__and3_1
X_8344_ display.refresh_counter\[9\] _3978_ VGND VGND VPWR VPWR _3980_ sky130_fd_sc_hd__and2_1
X_8275_ _3662_ _3785_ VGND VGND VPWR VPWR _3928_ sky130_fd_sc_hd__nor2_1
X_4507_ rf.registers\[25\]\[12\] _4165_ _4173_ rf.registers\[10\]\[12\] VGND VGND
+ VPWR VPWR _4316_ sky130_fd_sc_hd__a22o_1
X_5487_ _1144_ _1145_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__and2_1
X_7226_ _2859_ _2860_ _2880_ _2882_ VGND VGND VPWR VPWR _2883_ sky130_fd_sc_hd__o31ai_4
X_4438_ _4239_ _4245_ _4244_ VGND VGND VPWR VPWR _4247_ sky130_fd_sc_hd__and3_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire3 _2682_ VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_1
X_4369_ rf.registers\[25\]\[30\] _4167_ _4177_ rf.registers\[10\]\[30\] VGND VGND
+ VPWR VPWR _4178_ sky130_fd_sc_hd__a22o_1
X_7157_ _2759_ _2787_ _2813_ _2776_ VGND VGND VPWR VPWR _2814_ sky130_fd_sc_hd__o2bb2a_1
X_6108_ _1699_ _1700_ _1610_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__a21boi_4
X_7088_ _2710_ _2736_ _2740_ VGND VGND VPWR VPWR _2745_ sky130_fd_sc_hd__a21oi_2
X_6039_ _1696_ _1596_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_1_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6390_ _1929_ _2048_ VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__xor2_2
X_5410_ _1012_ _0974_ _1068_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5341_ _0995_ _0999_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8060_ _3710_ _3711_ _3712_ VGND VGND VPWR VPWR _3713_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_2_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5272_ _0841_ _0849_ _0930_ _0840_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__o22ai_1
X_7011_ _2667_ VGND VGND VPWR VPWR _2668_ sky130_fd_sc_hd__clkbuf_2
X_7913_ _3565_ _3563_ _3561_ VGND VGND VPWR VPWR _3566_ sky130_fd_sc_hd__o21a_1
XFILLER_0_77_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7844_ _3484_ _3489_ _3485_ VGND VGND VPWR VPWR _3497_ sky130_fd_sc_hd__o21a_1
XFILLER_0_77_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7775_ _3385_ _3427_ VGND VGND VPWR VPWR _3428_ sky130_fd_sc_hd__nor2_1
X_6726_ _2377_ _2372_ _2382_ VGND VGND VPWR VPWR _2383_ sky130_fd_sc_hd__a21o_4
X_4987_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_554 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6657_ _2144_ _2156_ _2219_ _2229_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__a31o_1
X_6588_ _2078_ _2102_ VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5608_ _0971_ _1156_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__nor2_1
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_103_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5539_ _1183_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__nor2_1
X_8327_ display.refresh_counter\[0\] display.refresh_counter\[1\] display.refresh_counter\[2\]
+ VGND VGND VPWR VPWR _3970_ sky130_fd_sc_hd__and3_1
XFILLER_0_103_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8258_ net7 _3910_ VGND VGND VPWR VPWR _3911_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_6_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8189_ _3732_ _3757_ VGND VGND VPWR VPWR _3842_ sky130_fd_sc_hd__or2_1
X_7209_ _2392_ _2865_ VGND VGND VPWR VPWR _2866_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4910_ _4160_ _4194_ _0445_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__nor3_2
X_5890_ _1428_ _1548_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__xor2_1
X_4841_ _4281_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__inv_2
X_4772_ _0358_ _0458_ _0465_ _4193_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__a22o_1
XFILLER_0_23_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7560_ _3205_ _3214_ VGND VGND VPWR VPWR _3215_ sky130_fd_sc_hd__nand2_1
X_6511_ _2164_ _2169_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__nand2_1
X_7491_ _0480_ _3145_ _3139_ VGND VGND VPWR VPWR _3146_ sky130_fd_sc_hd__o21a_1
X_6442_ _2093_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__buf_4
XFILLER_0_15_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8112_ _3763_ _3764_ VGND VGND VPWR VPWR _3765_ sky130_fd_sc_hd__or2b_1
X_6373_ _1913_ _2031_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5324_ _0890_ _0982_ _0940_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8043_ _2287_ _3695_ VGND VGND VPWR VPWR _3696_ sky130_fd_sc_hd__or2_4
X_5255_ _0626_ _0857_ _0912_ _0901_ _0913_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__a221o_1
XFILLER_0_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5186_ _0769_ _0739_ _0778_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__nand3_1
XFILLER_0_97_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7827_ _3479_ VGND VGND VPWR VPWR _3480_ sky130_fd_sc_hd__inv_2
X_7758_ _3409_ _3410_ VGND VGND VPWR VPWR _3411_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6709_ _1689_ _2339_ VGND VGND VPWR VPWR _2366_ sky130_fd_sc_hd__nor2_1
X_7689_ _3341_ VGND VGND VPWR VPWR _3342_ sky130_fd_sc_hd__buf_2
XFILLER_0_104_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_354 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5040_ _0616_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_88_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6991_ _2602_ _2647_ VGND VGND VPWR VPWR _2648_ sky130_fd_sc_hd__xnor2_2
X_8730_ clknet_4_9_0_clk _0104_ VGND VGND VPWR VPWR rf.registers\[15\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_5942_ _0651_ _1588_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8661_ net205 _4130_ VGND VGND VPWR VPWR _4132_ sky130_fd_sc_hd__and2_1
X_5873_ _1275_ _1512_ _1531_ _1530_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__o211a_1
X_7612_ _3266_ VGND VGND VPWR VPWR _3267_ sky130_fd_sc_hd__inv_2
XFILLER_0_47_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8592_ _4095_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
X_4824_ _0469_ _0508_ _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__a21o_1
XFILLER_0_90_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7543_ _3187_ _3191_ _3189_ VGND VGND VPWR VPWR _3198_ sky130_fd_sc_hd__o21a_1
XFILLER_0_43_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4755_ _0321_ _4255_ _0320_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__and3_1
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4686_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__buf_2
X_7474_ net61 _3128_ VGND VGND VPWR VPWR _3129_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6425_ net114 _1944_ net105 _2083_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__a31o_1
X_6356_ _1873_ _2009_ VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__xnor2_1
X_5307_ _0865_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__xnor2_1
X_8026_ _2384_ _3669_ _3677_ _3678_ VGND VGND VPWR VPWR _3679_ sky130_fd_sc_hd__a31o_1
X_6287_ _0646_ _1834_ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__and2_1
X_5238_ _0649_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__xnor2_1
X_5169_ _0657_ _0797_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__or2_1
XFILLER_0_98_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclone2 _1114_ _0909_ _1115_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__a21oi_4
XFILLER_0_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8859_ clknet_4_0_0_clk _0002_ VGND VGND VPWR VPWR display.refresh_counter\[11\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_104_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_89_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4540_ rf.registers\[25\]\[4\] _4164_ _4172_ rf.registers\[10\]\[4\] VGND VGND VPWR
+ VPWR _0237_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4471_ _4276_ _4279_ VGND VGND VPWR VPWR _4280_ sky130_fd_sc_hd__or2_1
X_6210_ _1703_ _1718_ _1719_ _1720_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7190_ _2840_ _2841_ VGND VGND VPWR VPWR _2847_ sky130_fd_sc_hd__xnor2_1
X_6141_ _0645_ _1695_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6072_ _1607_ _1730_ _1723_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__mux2_1
X_5023_ net29 _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__xnor2_2
X_6974_ _2629_ _2630_ VGND VGND VPWR VPWR _2631_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8713_ clknet_4_6_0_clk _0087_ VGND VGND VPWR VPWR rf.registers\[25\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_5925_ net65 _1494_ _1533_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__mux2_1
X_8644_ net184 _4119_ VGND VGND VPWR VPWR _4123_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5856_ _1353_ _1514_ _1455_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__mux2_4
XFILLER_0_48_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4807_ _4266_ _4267_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__or2_1
XFILLER_0_106_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8575_ _4086_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5787_ _1300_ _1336_ _1331_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__o21ba_1
X_4738_ _0375_ _0432_ _0367_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7526_ _3172_ _3176_ VGND VGND VPWR VPWR _3181_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7457_ _2396_ _3089_ _3112_ VGND VGND VPWR VPWR _3113_ sky130_fd_sc_hd__a21oi_1
X_4669_ _4299_ _0365_ _0335_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6408_ _1889_ _2061_ _2064_ _1689_ VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7388_ _3038_ _3044_ VGND VGND VPWR VPWR _3045_ sky130_fd_sc_hd__nor2_1
XFILLER_0_101_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6339_ _1843_ _1952_ _1959_ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__and3_1
X_8009_ _2376_ _3661_ VGND VGND VPWR VPWR _3662_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_106_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_97_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5710_ _1368_ _1334_ _1283_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__a21o_1
X_6690_ _2296_ _2343_ _2346_ _2124_ VGND VGND VPWR VPWR _2347_ sky130_fd_sc_hd__a211o_1
XFILLER_0_17_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5641_ _1292_ _1293_ _1295_ _1299_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__or4_4
XFILLER_0_31_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5572_ net68 VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__buf_6
XFILLER_0_25_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8360_ _3988_ _3989_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8291_ net32 net5 _3639_ _3941_ _3943_ VGND VGND VPWR VPWR _3944_ sky130_fd_sc_hd__a221o_1
X_4523_ _4205_ _4331_ VGND VGND VPWR VPWR _4332_ sky130_fd_sc_hd__nand2_1
X_7311_ _2951_ _2965_ _2967_ VGND VGND VPWR VPWR _2968_ sky130_fd_sc_hd__o21bai_4
XFILLER_0_41_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7242_ _2895_ _2898_ VGND VGND VPWR VPWR _2899_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4454_ _4232_ _4262_ VGND VGND VPWR VPWR _4263_ sky130_fd_sc_hd__or2_1
X_4385_ rf.registers\[15\]\[4\] _4171_ _4193_ VGND VGND VPWR VPWR _4194_ sky130_fd_sc_hd__a21o_2
X_7173_ _2822_ _2816_ _2828_ VGND VGND VPWR VPWR _2830_ sky130_fd_sc_hd__a21oi_1
X_6124_ _1741_ _1746_ _1753_ _1758_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__and4_1
X_6055_ _1713_ _1595_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__xnor2_1
X_5006_ net26 _0653_ _0655_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_69_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6957_ _2571_ _2572_ VGND VGND VPWR VPWR _2614_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_52_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6888_ _2541_ _2542_ _2518_ _2544_ VGND VGND VPWR VPWR _2545_ sky130_fd_sc_hd__a31o_1
X_5908_ _1385_ _0770_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8627_ net144 _4108_ VGND VGND VPWR VPWR _4114_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5839_ _1492_ _0635_ _1496_ _1497_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__a31o_1
XFILLER_0_106_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8558_ _4077_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7509_ _0505_ _3153_ _3156_ VGND VGND VPWR VPWR _3164_ sky130_fd_sc_hd__or3_1
X_8489_ net158 _4056_ VGND VGND VPWR VPWR _4057_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_80_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7860_ _3372_ _3501_ _3503_ VGND VGND VPWR VPWR _3513_ sky130_fd_sc_hd__or3_1
X_6811_ _2454_ _2456_ _2457_ _2467_ VGND VGND VPWR VPWR _2468_ sky130_fd_sc_hd__a211o_1
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7791_ _3443_ _3439_ _3441_ VGND VGND VPWR VPWR _3444_ sky130_fd_sc_hd__o21a_1
X_6742_ _2398_ VGND VGND VPWR VPWR _2399_ sky130_fd_sc_hd__buf_2
X_6673_ _2328_ _2329_ VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8412_ _4015_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5624_ _1231_ _1280_ _1281_ _1282_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_45_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8343_ _3978_ net123 VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5555_ _1195_ _1199_ _1203_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__nand4_4
X_8274_ _3923_ _3854_ _3926_ VGND VGND VPWR VPWR _3927_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4506_ _4310_ _4313_ VGND VGND VPWR VPWR _4315_ sky130_fd_sc_hd__nand2_1
X_5486_ _0726_ _1136_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__nand2_1
X_4437_ _4239_ _4244_ _4245_ VGND VGND VPWR VPWR _4246_ sky130_fd_sc_hd__a21oi_1
X_7225_ _2845_ _2856_ _2881_ VGND VGND VPWR VPWR _2882_ sky130_fd_sc_hd__o21a_1
X_7156_ _2763_ _2774_ _2760_ VGND VGND VPWR VPWR _2813_ sky130_fd_sc_hd__o21a_1
X_6107_ _1582_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__buf_4
X_4368_ _4176_ VGND VGND VPWR VPWR _4177_ sky130_fd_sc_hd__clkbuf_4
X_7087_ _2725_ _2727_ _2729_ VGND VGND VPWR VPWR _2744_ sky130_fd_sc_hd__or3_2
X_6038_ _1696_ _1596_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_1_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer40 _3786_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_2
XFILLER_0_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7989_ _0595_ net5 _3116_ VGND VGND VPWR VPWR _3642_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_68_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5340_ _0643_ _0998_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__nor2_1
X_5271_ _0839_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7010_ _2658_ _2659_ _2664_ _2666_ VGND VGND VPWR VPWR _2667_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_10_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7912_ _3352_ _3564_ VGND VGND VPWR VPWR _3565_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7843_ _3484_ _3488_ _3495_ VGND VGND VPWR VPWR _3496_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7774_ _3423_ _3426_ _3420_ VGND VGND VPWR VPWR _3427_ sky130_fd_sc_hd__o21a_1
X_4986_ net264 VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__buf_6
XFILLER_0_92_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6725_ _2376_ _2378_ _2380_ _2381_ VGND VGND VPWR VPWR _2382_ sky130_fd_sc_hd__a211o_2
XFILLER_0_73_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6656_ _2124_ _2122_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6587_ _2079_ _2091_ _2096_ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__and3_1
XFILLER_0_14_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5607_ _1156_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__inv_2
XFILLER_0_33_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5538_ _1190_ _1192_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__nand2b_1
X_8326_ net115 net132 VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__xor2_1
X_8257_ _0591_ _3909_ net92 VGND VGND VPWR VPWR _3910_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5469_ _1081_ _1082_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_6_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7208_ _2834_ _2854_ _2864_ VGND VGND VPWR VPWR _2865_ sky130_fd_sc_hd__a21bo_1
X_8188_ _3811_ _3839_ _3838_ _3840_ VGND VGND VPWR VPWR _3841_ sky130_fd_sc_hd__o31a_1
XFILLER_0_1_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7139_ _2763_ _2774_ VGND VGND VPWR VPWR _2796_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_70_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4840_ _4155_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__buf_2
XFILLER_0_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6510_ _2160_ _2168_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__or2b_1
X_4771_ _0461_ _0464_ _0445_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7490_ _3143_ _3144_ _3142_ VGND VGND VPWR VPWR _3145_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6441_ _2070_ _1980_ _2076_ _2088_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__a211o_4
XFILLER_0_15_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6372_ _1972_ _2030_ _1916_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8111_ _1618_ _3762_ VGND VGND VPWR VPWR _3764_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5323_ _0879_ _0886_ _0891_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_580 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8042_ _3692_ _3694_ net96 VGND VGND VPWR VPWR _3695_ sky130_fd_sc_hd__mux2_4
X_5254_ _0626_ _0857_ _0903_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__o21a_1
X_5185_ _0830_ _0798_ _0842_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__a31o_1
XFILLER_0_97_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7826_ _3377_ _3478_ VGND VGND VPWR VPWR _3479_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4969_ _0627_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__buf_6
X_7757_ _3386_ _3408_ VGND VGND VPWR VPWR _3410_ sky130_fd_sc_hd__and2_1
X_6708_ _2340_ _2345_ _2347_ _2364_ VGND VGND VPWR VPWR _2365_ sky130_fd_sc_hd__and4_1
X_7688_ _3332_ VGND VGND VPWR VPWR _3341_ sky130_fd_sc_hd__buf_4
X_6639_ _2180_ _2288_ _2178_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__or3_1
XFILLER_0_61_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_366 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8309_ _3960_ VGND VGND VPWR VPWR _3961_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_17_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6990_ _2601_ _2627_ VGND VGND VPWR VPWR _2647_ sky130_fd_sc_hd__nand2_1
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
X_5941_ _1597_ _1599_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8660_ _4131_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5872_ _1275_ _1512_ _1515_ _1484_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__a211o_1
X_7611_ _0573_ _3265_ VGND VGND VPWR VPWR _3266_ sky130_fd_sc_hd__xor2_1
X_8591_ net145 _4094_ VGND VGND VPWR VPWR _4095_ sky130_fd_sc_hd__and2_1
X_4823_ _4154_ _0314_ _0509_ _0512_ _4193_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__a32o_1
XFILLER_0_7_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4754_ _0428_ _4157_ _0448_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__a21o_1
X_7542_ _3196_ VGND VGND VPWR VPWR _3197_ sky130_fd_sc_hd__inv_2
XFILLER_0_55_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7473_ _3125_ _3126_ _3127_ VGND VGND VPWR VPWR _3128_ sky130_fd_sc_hd__o21a_1
X_4685_ rf.registers\[5\]\[2\] _4150_ _4241_ rf.registers\[15\]\[2\] _4181_ VGND VGND
+ VPWR VPWR _0382_ sky130_fd_sc_hd__a221oi_2
XFILLER_0_70_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6424_ _1965_ _2082_ _1964_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__o21a_1
X_6355_ _1889_ _2010_ _2013_ VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__a21o_1
XFILLER_0_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6286_ _1795_ _1944_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5306_ _0649_ _0870_ _0964_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8025_ _2265_ _2384_ VGND VGND VPWR VPWR _3678_ sky130_fd_sc_hd__nor2_1
X_5237_ _0827_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__xor2_2
XFILLER_0_75_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5168_ _0796_ _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__or2_2
XFILLER_0_75_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5099_ _0625_ _0734_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__or3_1
Xclone3 _1566_ _1565_ _1567_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__a21oi_2
XFILLER_0_39_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8858_ clknet_4_0_0_clk _0001_ VGND VGND VPWR VPWR display.refresh_counter\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_104_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8789_ clknet_4_15_0_clk _0163_ VGND VGND VPWR VPWR rf.registers\[10\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_7809_ _3461_ _3456_ _3458_ VGND VGND VPWR VPWR _3462_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_414 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4470_ _4179_ _4226_ _4229_ VGND VGND VPWR VPWR _4279_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_94_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6140_ _1795_ _1798_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6071_ _1728_ _1729_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__xnor2_1
X_5022_ _0661_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6973_ _2601_ _2628_ _2602_ _2627_ VGND VGND VPWR VPWR _2630_ sky130_fd_sc_hd__nand4_2
X_5924_ _1578_ _1581_ _1582_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__a21oi_1
X_8712_ clknet_4_4_0_clk _0086_ VGND VGND VPWR VPWR rf.registers\[25\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_8643_ _4122_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5855_ _1397_ _1508_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__xor2_1
XFILLER_0_90_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4806_ _0495_ _0496_ _0445_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8574_ net162 _4083_ VGND VGND VPWR VPWR _4086_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5786_ _1438_ _1342_ _1444_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__and3_1
X_4737_ _0359_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__inv_2
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7525_ net62 _3179_ VGND VGND VPWR VPWR _3180_ sky130_fd_sc_hd__or2_1
X_7456_ _2395_ _3094_ _3111_ VGND VGND VPWR VPWR _3112_ sky130_fd_sc_hd__a21o_1
X_4668_ rf.registers\[25\]\[17\] _4167_ _4177_ rf.registers\[10\]\[17\] VGND VGND
+ VPWR VPWR _0365_ sky130_fd_sc_hd__a22o_1
X_6407_ _2057_ _2051_ _2062_ _2065_ VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__a211o_1
X_7387_ _3040_ _3041_ _3043_ VGND VGND VPWR VPWR _3044_ sky130_fd_sc_hd__and3_1
X_4599_ _4309_ _0293_ _0295_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_101_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6338_ net114 net105 _1996_ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__a21oi_1
X_6269_ _1768_ net90 _1837_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__and3_1
X_8008_ _2372_ _3660_ VGND VGND VPWR VPWR _3661_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_106_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5640_ _0971_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__xnor2_1
X_5571_ _0628_ _1229_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8290_ net35 _3942_ VGND VGND VPWR VPWR _3943_ sky130_fd_sc_hd__xnor2_1
X_4522_ _4201_ _4202_ _4203_ _4204_ _4187_ VGND VGND VPWR VPWR _4331_ sky130_fd_sc_hd__o32ai_1
X_7310_ _2916_ _2940_ _2966_ _2936_ VGND VGND VPWR VPWR _2967_ sky130_fd_sc_hd__o22ai_2
X_7241_ _2896_ _2897_ VGND VGND VPWR VPWR _2898_ sky130_fd_sc_hd__nand2_1
X_4453_ _4230_ _4261_ VGND VGND VPWR VPWR _4262_ sky130_fd_sc_hd__or2_1
X_4384_ _4192_ VGND VGND VPWR VPWR _4193_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_21_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7172_ _2822_ _2828_ _2816_ VGND VGND VPWR VPWR _2829_ sky130_fd_sc_hd__and3_1
X_6123_ _1726_ _1732_ _1781_ _1759_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__or4_4
XFILLER_0_56_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6054_ _0620_ _1711_ _1593_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5005_ _0662_ _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6956_ _2389_ _2612_ VGND VGND VPWR VPWR _2613_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_52_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5907_ _0926_ _1021_ _1563_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__nor3_2
XTAP_TAPCELL_ROW_101_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6887_ _2543_ VGND VGND VPWR VPWR _2544_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8626_ _4113_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5838_ net65 _0620_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__nor2_1
X_8557_ net216 _4072_ VGND VGND VPWR VPWR _4077_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_60_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5769_ _1121_ _1341_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7508_ _0515_ _3162_ VGND VGND VPWR VPWR _3163_ sky130_fd_sc_hd__nor2_1
X_8488_ _4033_ VGND VGND VPWR VPWR _4056_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_102_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7439_ _3072_ _3093_ VGND VGND VPWR VPWR _3095_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6810_ _2464_ _2466_ VGND VGND VPWR VPWR _2467_ sky130_fd_sc_hd__nor2_1
X_7790_ _3442_ _3381_ VGND VGND VPWR VPWR _3443_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6741_ _2397_ VGND VGND VPWR VPWR _2398_ sky130_fd_sc_hd__buf_2
XFILLER_0_9_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6672_ _2172_ _2327_ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8411_ net256 _0561_ _4008_ VGND VGND VPWR VPWR _4015_ sky130_fd_sc_hd__mux2_1
X_5623_ _1151_ _1231_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8342_ display.refresh_counter\[7\] _3976_ net122 VGND VGND VPWR VPWR _3979_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_103_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5554_ _1209_ _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__and2_1
X_8273_ _3837_ _3924_ _3925_ VGND VGND VPWR VPWR _3926_ sky130_fd_sc_hd__a21o_1
X_4505_ _4310_ _4313_ VGND VGND VPWR VPWR _4314_ sky130_fd_sc_hd__or2_1
X_5485_ _0726_ _1136_ _1143_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4436_ rf.registers\[25\]\[29\] _4167_ _4241_ rf.registers\[10\]\[29\] VGND VGND
+ VPWR VPWR _4245_ sky130_fd_sc_hd__a22oi_1
X_7224_ _2403_ _2856_ _2853_ VGND VGND VPWR VPWR _2881_ sky130_fd_sc_hd__o21ai_1
Xwire5 _4146_ VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_1
X_4367_ _4175_ VGND VGND VPWR VPWR _4176_ sky130_fd_sc_hd__clkbuf_4
X_7155_ _2808_ net55 _2810_ _2811_ VGND VGND VPWR VPWR _2812_ sky130_fd_sc_hd__o31ai_2
X_6106_ _1764_ _0645_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7086_ _2703_ _2704_ _2741_ _2742_ VGND VGND VPWR VPWR _2743_ sky130_fd_sc_hd__a31o_1
X_6037_ _1601_ _1589_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__or2b_1
Xrebuffer30 net111 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_1_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer41 net112 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_68_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7988_ net35 _2396_ _3639_ _3640_ VGND VGND VPWR VPWR _3641_ sky130_fd_sc_hd__o31a_1
XFILLER_0_95_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6939_ _2595_ VGND VGND VPWR VPWR _2596_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8609_ net248 _4094_ VGND VGND VPWR VPWR _4104_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5270_ _0906_ _0907_ _0928_ _0685_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__o211a_1
XFILLER_0_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7911_ _3548_ _3552_ _3558_ _3562_ VGND VGND VPWR VPWR _3564_ sky130_fd_sc_hd__a31o_1
X_7842_ _3374_ _3489_ _3483_ VGND VGND VPWR VPWR _3495_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4985_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__buf_4
X_7773_ _3385_ _3425_ VGND VGND VPWR VPWR _3426_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6724_ _2099_ _2296_ VGND VGND VPWR VPWR _2381_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6655_ _1679_ VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_6
XFILLER_0_73_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6586_ _2091_ _2096_ _2079_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__a21oi_1
X_5606_ _1257_ _1253_ _1264_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__or3b_4
XFILLER_0_5_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5537_ _0924_ _1117_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__xnor2_1
X_8325_ net115 VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__inv_2
XFILLER_0_103_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8256_ _3701_ _3908_ VGND VGND VPWR VPWR _3909_ sky130_fd_sc_hd__or2_1
X_5468_ _1051_ _1065_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__nor2_1
X_7207_ _2863_ _2833_ _2854_ _2832_ VGND VGND VPWR VPWR _2864_ sky130_fd_sc_hd__a31o_1
X_8187_ _3762_ _3811_ VGND VGND VPWR VPWR _3840_ sky130_fd_sc_hd__nand2_1
X_5399_ net63 _0627_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__nand2_1
X_4419_ rf.registers\[5\]\[22\] _4149_ _4175_ rf.registers\[15\]\[22\] VGND VGND VPWR
+ VPWR _4228_ sky130_fd_sc_hd__a22o_1
X_7138_ _2763_ _2774_ _2787_ VGND VGND VPWR VPWR _2795_ sky130_fd_sc_hd__a21o_1
X_7069_ _2678_ _2679_ VGND VGND VPWR VPWR _2726_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_75_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4770_ _0383_ _0462_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6440_ _1963_ _2098_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__xnor2_2
X_6371_ _1930_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__inv_2
X_8110_ _1618_ _3762_ VGND VGND VPWR VPWR _3763_ sky130_fd_sc_hd__nor2_1
X_5322_ _0800_ _0872_ _0889_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8041_ _3693_ _2253_ VGND VGND VPWR VPWR _3694_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5253_ _0861_ _0858_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__nor2b_1
X_5184_ _0794_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_78_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xwire54 _1319_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
XFILLER_0_78_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7825_ _3475_ _3477_ VGND VGND VPWR VPWR _3478_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4968_ _0626_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__buf_6
XFILLER_0_19_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7756_ _3386_ _3408_ VGND VGND VPWR VPWR _3409_ sky130_fd_sc_hd__nor2_1
X_7687_ net35 _3339_ net2 VGND VGND VPWR VPWR _3340_ sky130_fd_sc_hd__mux2_1
X_6707_ _2276_ _2353_ _2358_ _2172_ VGND VGND VPWR VPWR _2364_ sky130_fd_sc_hd__o22ai_1
X_4899_ _0573_ _4156_ _0575_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__a21o_1
X_6638_ _2283_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__buf_6
XFILLER_0_34_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8308_ _3799_ _3804_ _3959_ _3629_ VGND VGND VPWR VPWR _3960_ sky130_fd_sc_hd__o2bb2a_1
X_6569_ _1689_ _2227_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__nor2_1
X_8239_ _3704_ _3705_ VGND VGND VPWR VPWR _3892_ sky130_fd_sc_hd__xor2_1
XFILLER_0_69_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5940_ _1490_ _1598_ _1568_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__mux2_4
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7610_ _3259_ _3262_ _3264_ VGND VGND VPWR VPWR _3265_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5871_ _1513_ _1518_ _1528_ _1529_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__or4bb_4
X_4822_ _0510_ _0511_ _4199_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8590_ _4071_ VGND VGND VPWR VPWR _4094_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_99_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7541_ net20 _3195_ VGND VGND VPWR VPWR _3196_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4753_ _4158_ _0430_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__a21o_1
X_7472_ _0388_ _3124_ VGND VGND VPWR VPWR _3127_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6423_ _1931_ _1941_ _1945_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__and3_1
X_4684_ _0378_ _0380_ _0376_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6354_ _1863_ _2012_ _1961_ VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6285_ _1826_ _1825_ _1942_ _1943_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__o31a_1
X_5305_ _0871_ _0878_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nor2_1
X_8024_ _3676_ _2282_ _3668_ VGND VGND VPWR VPWR _3677_ sky130_fd_sc_hd__a21o_1
X_5236_ _0894_ _0853_ _0854_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__or3_1
XFILLER_0_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5167_ _0795_ _0789_ _0766_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__a21oi_1
X_5098_ _0709_ _0623_ _0707_ _0708_ _0756_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a32oi_1
Xclone4 _1333_ _1325_ _0644_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__a21oi_2
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8857_ clknet_4_0_0_clk _0019_ VGND VGND VPWR VPWR display.refresh_counter\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8788_ clknet_4_14_0_clk _0162_ VGND VGND VPWR VPWR rf.registers\[10\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7808_ _3379_ _3460_ VGND VGND VPWR VPWR _3461_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7739_ _3387_ _3391_ _3389_ VGND VGND VPWR VPWR _3392_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_570 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6070_ _1597_ _1599_ _1602_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__o21ai_1
X_5021_ _0662_ _0670_ _0679_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__o21ai_1
X_6972_ _2601_ _2602_ _2627_ _2628_ VGND VGND VPWR VPWR _2629_ sky130_fd_sc_hd__a31o_1
X_8711_ clknet_4_1_0_clk _0085_ VGND VGND VPWR VPWR rf.registers\[25\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5923_ _1484_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__buf_4
X_8642_ net202 _4119_ VGND VGND VPWR VPWR _4122_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5854_ _1275_ _1512_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__xnor2_1
X_8573_ _4085_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
X_4805_ _0436_ _0439_ _0369_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7524_ net24 _3176_ VGND VGND VPWR VPWR _3179_ sky130_fd_sc_hd__xnor2_1
X_5785_ _1427_ _1428_ _1443_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__or3_1
XFILLER_0_90_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4736_ _0380_ _0373_ _0376_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7455_ net5 _3097_ _3110_ VGND VGND VPWR VPWR _3111_ sky130_fd_sc_hd__a21oi_1
X_4667_ _4290_ _4286_ _0335_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__mux2_1
X_7386_ _3036_ _3042_ VGND VGND VPWR VPWR _3043_ sky130_fd_sc_hd__nor2_1
X_6406_ _1689_ _2064_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6337_ _1844_ _1995_ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__nand2_1
X_4598_ _4305_ _0294_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__or2_1
X_6268_ _1726_ _1732_ _1907_ _1926_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__a2bb2o_1
X_8007_ _2372_ _2377_ _2382_ VGND VGND VPWR VPWR _3660_ sky130_fd_sc_hd__a21oi_4
X_6199_ _1439_ _1853_ _1855_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__or3_1
X_5219_ _0618_ _0874_ _0875_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__a2bb2oi_1
XTAP_TAPCELL_ROW_106_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xsplit24 display.refresh_counter\[17\] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__buf_1
XFILLER_0_81_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5570_ _1136_ _1228_ _1221_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__mux2_2
X_4521_ rf.registers\[25\]\[8\] _4165_ _4173_ rf.registers\[10\]\[8\] VGND VGND VPWR
+ VPWR _4330_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7240_ _2873_ net53 _2872_ VGND VGND VPWR VPWR _2897_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4452_ _4179_ _4226_ VGND VGND VPWR VPWR _4261_ sky130_fd_sc_hd__and2_1
X_4383_ rf.registers\[5\]\[4\] net60 VGND VGND VPWR VPWR _4192_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7171_ _1167_ _2779_ _2827_ VGND VGND VPWR VPWR _2828_ sky130_fd_sc_hd__o21a_1
X_6122_ _1765_ _1769_ _1774_ _1780_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__or4b_4
X_6053_ _1711_ _1692_ _1693_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__and3b_1
X_5004_ net27 _0616_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6955_ _2560_ _2611_ _2605_ VGND VGND VPWR VPWR _2612_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5906_ _1552_ _1329_ _1558_ _1563_ _1564_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__a2111o_1
XTAP_TAPCELL_ROW_101_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8625_ net141 _4108_ VGND VGND VPWR VPWR _4113_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6886_ _2509_ _2510_ VGND VGND VPWR VPWR _2543_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5837_ _1406_ _1495_ _1456_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8556_ _4076_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5768_ _1121_ _1426_ _1118_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__a21o_1
X_4719_ _0413_ _0414_ _0367_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__mux2_1
X_8487_ _4055_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
X_7507_ _3160_ _3161_ VGND VGND VPWR VPWR _3162_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7438_ _3090_ _3092_ _3093_ VGND VGND VPWR VPWR _3094_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5699_ _1120_ _1240_ _1241_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__and3_1
XFILLER_0_102_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7369_ _3018_ _3025_ VGND VGND VPWR VPWR _3026_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_80_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6740_ _2386_ VGND VGND VPWR VPWR _2397_ sky130_fd_sc_hd__inv_2
X_6671_ _2172_ _2327_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__or2_1
X_8410_ _4014_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
X_5622_ _1267_ _1271_ _1171_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_26_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5553_ _1021_ _1211_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__nor2_1
X_8341_ display.refresh_counter\[7\] display.refresh_counter\[8\] _3976_ VGND VGND
+ VPWR VPWR _3978_ sky130_fd_sc_hd__and3_1
X_4504_ _4312_ _4293_ VGND VGND VPWR VPWR _4313_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8272_ _3830_ _3835_ _3851_ VGND VGND VPWR VPWR _3925_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5484_ _1035_ _1137_ _1138_ _1142_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__a31o_1
X_7223_ _2866_ _2875_ _2879_ _2865_ _2392_ VGND VGND VPWR VPWR _2880_ sky130_fd_sc_hd__o32a_2
X_4435_ _4236_ _4237_ _4238_ _4187_ VGND VGND VPWR VPWR _4244_ sky130_fd_sc_hd__o22ai_2
X_4366_ _4174_ VGND VGND VPWR VPWR _4175_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7154_ _2806_ _2807_ _2391_ VGND VGND VPWR VPWR _2811_ sky130_fd_sc_hd__a21o_1
X_6105_ _1763_ _1651_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7085_ _2727_ VGND VGND VPWR VPWR _2742_ sky130_fd_sc_hd__inv_2
X_6036_ _1573_ _1669_ _1694_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__mux2_1
Xrebuffer31 net106 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer42 _2372_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_68_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7987_ _0595_ net5 VGND VGND VPWR VPWR _3640_ sky130_fd_sc_hd__or2_1
X_6938_ _2562_ _2563_ VGND VGND VPWR VPWR _2595_ sky130_fd_sc_hd__or2_1
XFILLER_0_76_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6869_ _2404_ _2521_ _2523_ _2525_ VGND VGND VPWR VPWR _2526_ sky130_fd_sc_hd__a211o_2
XFILLER_0_36_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8608_ _4103_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_106_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8539_ _4070_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__inv_2
XFILLER_0_106_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7910_ _3555_ _3562_ VGND VGND VPWR VPWR _3563_ sky130_fd_sc_hd__xnor2_1
X_7841_ _3490_ _3493_ VGND VGND VPWR VPWR _3494_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4984_ _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__buf_4
X_7772_ _3422_ _3424_ VGND VGND VPWR VPWR _3425_ sky130_fd_sc_hd__or2_1
X_6723_ _2108_ _2379_ _2233_ _2248_ VGND VGND VPWR VPWR _2380_ sky130_fd_sc_hd__o31a_1
X_6654_ _2292_ _2308_ _2311_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5605_ _0952_ _1260_ _1261_ _1263_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__a2bb2o_2
X_6585_ _2242_ _2243_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5536_ _1181_ _1146_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__nand2_4
X_8324_ _3969_ VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XFILLER_0_41_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8255_ _0591_ net6 VGND VGND VPWR VPWR _3908_ sky130_fd_sc_hd__and2_1
X_5467_ _1066_ _1033_ _1071_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_78_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4418_ rf.registers\[5\]\[23\] _4149_ _4175_ rf.registers\[15\]\[23\] VGND VGND VPWR
+ VPWR _4227_ sky130_fd_sc_hd__a22o_1
X_7206_ _2861_ _2862_ VGND VGND VPWR VPWR _2863_ sky130_fd_sc_hd__nand2_1
X_8186_ _3776_ _3765_ _3812_ VGND VGND VPWR VPWR _3839_ sky130_fd_sc_hd__and3_1
X_5398_ _1052_ _1053_ _0954_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__a21o_1
X_4349_ _4154_ VGND VGND VPWR VPWR _4158_ sky130_fd_sc_hd__clkbuf_4
X_7137_ _2792_ _2793_ VGND VGND VPWR VPWR _2794_ sky130_fd_sc_hd__nor2_1
X_7068_ net63 _2724_ _2700_ _2701_ VGND VGND VPWR VPWR _2725_ sky130_fd_sc_hd__a22o_1
X_6019_ _1675_ _1677_ _1666_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6370_ _0638_ _2027_ _2014_ _2028_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_97_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5321_ _0884_ _0979_ _0941_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8040_ _1486_ _3692_ _2252_ VGND VGND VPWR VPWR _3693_ sky130_fd_sc_hd__o21ai_1
X_5252_ _0906_ _0896_ _0901_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__o21ba_1
X_5183_ _0834_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__inv_2
XFILLER_0_64_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7824_ _3466_ _3474_ VGND VGND VPWR VPWR _3477_ sky130_fd_sc_hd__and2_1
Xwire55 net262 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_1
XFILLER_0_80_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4967_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__buf_4
X_7755_ _3402_ _3405_ _3407_ VGND VGND VPWR VPWR _3408_ sky130_fd_sc_hd__a21oi_1
X_6706_ _2340_ _2345_ _2347_ _2362_ VGND VGND VPWR VPWR _2363_ sky130_fd_sc_hd__and4_1
X_7686_ _3319_ _3336_ net3 VGND VGND VPWR VPWR _3339_ sky130_fd_sc_hd__mux2_1
X_4898_ _0550_ _0286_ _0574_ _0477_ _0469_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__a32o_1
X_6637_ _2174_ _2294_ _2283_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__mux2_1
X_6568_ _2130_ _2136_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__nand2_1
X_8307_ _3802_ _3804_ _3798_ VGND VGND VPWR VPWR _3959_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5519_ _1134_ _1177_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__nand2_1
X_6499_ _1889_ _2010_ VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__nand2_1
X_8238_ _3706_ _3890_ VGND VGND VPWR VPWR _3891_ sky130_fd_sc_hd__xnor2_1
X_8169_ _3786_ VGND VGND VPWR VPWR _3822_ sky130_fd_sc_hd__buf_6
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5870_ _0636_ _1521_ _1524_ _1385_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__a2bb2o_1
X_4821_ _0376_ _0255_ _0372_ _0383_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__and4b_1
XFILLER_0_75_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4752_ _0358_ _0438_ _0446_ _4193_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7540_ _3192_ _3194_ VGND VGND VPWR VPWR _3195_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_99_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7471_ net61 _3122_ VGND VGND VPWR VPWR _3126_ sky130_fd_sc_hd__nor2_1
X_4683_ _4248_ _0379_ _0372_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__mux2_1
X_6422_ _1963_ _1968_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6353_ _1864_ _2011_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__xor2_1
X_6284_ _1803_ _1822_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5304_ _0915_ _0922_ _0929_ _0936_ _0938_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a41o_1
X_8023_ _2302_ _2265_ VGND VGND VPWR VPWR _3676_ sky130_fd_sc_hd__nand2_1
X_5235_ _0799_ _0825_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__and2_1
X_5166_ _0820_ _0805_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_3_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5097_ _0619_ _0707_ _0710_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_39_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8856_ clknet_4_0_0_clk _0018_ VGND VGND VPWR VPWR display.refresh_counter\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_104_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8787_ clknet_4_14_0_clk _0161_ VGND VGND VPWR VPWR rf.registers\[10\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_7807_ _3455_ _3459_ VGND VGND VPWR VPWR _3460_ sky130_fd_sc_hd__or2_1
X_5999_ _1294_ _1621_ _1657_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__o21ai_1
X_7738_ _3333_ _3125_ _3390_ VGND VGND VPWR VPWR _3391_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_22_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_49_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7669_ _0595_ _3305_ _3317_ VGND VGND VPWR VPWR _3324_ sky130_fd_sc_hd__or3_1
XFILLER_0_22_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_582 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_67_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_76_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5020_ _0678_ _0676_ net34 _0623_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__o211a_4
XFILLER_0_29_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6971_ _2616_ VGND VGND VPWR VPWR _2628_ sky130_fd_sc_hd__inv_2
X_8710_ clknet_4_4_0_clk _0084_ VGND VGND VPWR VPWR rf.registers\[25\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_88_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_563 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5922_ _1542_ _1570_ _1580_ _1575_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_85_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8641_ _4121_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
X_5853_ _1350_ _1511_ _1456_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__mux2_4
X_8572_ net176 _4083_ VGND VGND VPWR VPWR _4085_ sky130_fd_sc_hd__and2_1
X_4804_ _0433_ _0435_ _0369_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5784_ _1440_ _1441_ _1442_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7523_ _3169_ _3172_ _3177_ VGND VGND VPWR VPWR _3178_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4735_ _0323_ _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__xnor2_1
X_7454_ _3105_ _3108_ _3109_ VGND VGND VPWR VPWR _3110_ sky130_fd_sc_hd__and3_1
X_4666_ _0362_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__inv_2
XFILLER_0_16_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7385_ _3012_ _3031_ _3007_ VGND VGND VPWR VPWR _3042_ sky130_fd_sc_hd__a21oi_1
X_6405_ _1904_ _2063_ _1964_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4597_ _4304_ _4303_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6336_ net67 _0630_ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6267_ _1766_ _1768_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__or2_1
X_8006_ _3633_ _3656_ _3658_ VGND VGND VPWR VPWR _3659_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_86_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6198_ _1853_ _1855_ _1856_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__o21ai_1
X_5218_ _0876_ _0633_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__nand2_1
X_5149_ _0807_ _0633_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_106_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8839_ clknet_4_2_0_clk _0213_ VGND VGND VPWR VPWR rf.registers\[5\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4520_ _4326_ _4328_ VGND VGND VPWR VPWR _4329_ sky130_fd_sc_hd__and2_1
XFILLER_0_103_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4451_ rf.registers\[25\]\[25\] _4166_ _4176_ rf.registers\[10\]\[25\] VGND VGND
+ VPWR VPWR _4260_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7170_ _2779_ _2783_ VGND VGND VPWR VPWR _2827_ sky130_fd_sc_hd__nand2_1
X_4382_ rf.registers\[5\]\[5\] _4147_ _4171_ rf.registers\[15\]\[5\] VGND VGND VPWR
+ VPWR _4191_ sky130_fd_sc_hd__a22o_1
X_6121_ _1582_ _1768_ _1779_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_0_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6052_ _1591_ _1592_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5003_ net27 _0615_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_93_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6954_ _2578_ _2610_ VGND VGND VPWR VPWR _2611_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5905_ _0645_ _0776_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_101_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8624_ _4112_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
X_6885_ _2511_ _2512_ VGND VGND VPWR VPWR _2542_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5836_ _1494_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__inv_2
XFILLER_0_106_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8555_ net139 _4072_ VGND VGND VPWR VPWR _4076_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_60_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5767_ _1372_ _1423_ _1424_ _1425_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_32_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4718_ _4304_ _4299_ _0335_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__mux2_1
X_8486_ net217 _4045_ VGND VGND VPWR VPWR _4055_ sky130_fd_sc_hd__and2_1
X_5698_ _1265_ _1277_ _1284_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__a21o_1
X_7506_ _0505_ _3159_ VGND VGND VPWR VPWR _3161_ sky130_fd_sc_hd__nand2_1
X_7437_ net5 _3064_ _3088_ VGND VGND VPWR VPWR _3093_ sky130_fd_sc_hd__a21o_1
X_4649_ _4188_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_31_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7368_ _3023_ _3024_ _3000_ VGND VGND VPWR VPWR _3025_ sky130_fd_sc_hd__mux2_1
X_6319_ _1888_ _1977_ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__xor2_1
X_7299_ _2923_ _2929_ _2939_ VGND VGND VPWR VPWR _2956_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_4_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6670_ _2127_ _2326_ _2283_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5621_ _1267_ _1271_ _1171_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__or3_1
XFILLER_0_60_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8340_ net135 _3976_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__xor2_1
X_5552_ _0650_ _1210_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__nor2_1
X_8271_ _3845_ _3846_ _3821_ VGND VGND VPWR VPWR _3924_ sky130_fd_sc_hd__a21o_1
X_4503_ _4210_ _4212_ _4311_ _4211_ VGND VGND VPWR VPWR _4312_ sky130_fd_sc_hd__o31a_1
XFILLER_0_5_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5483_ _1139_ _1141_ _1116_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__mux2_2
XFILLER_0_41_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7222_ _2876_ _2878_ VGND VGND VPWR VPWR _2879_ sky130_fd_sc_hd__nand2_1
X_4434_ _4240_ _4242_ VGND VGND VPWR VPWR _4243_ sky130_fd_sc_hd__xor2_2
XFILLER_0_1_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4365_ _4173_ VGND VGND VPWR VPWR _4174_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_67_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7153_ _2778_ _2780_ _2792_ _2793_ VGND VGND VPWR VPWR _2810_ sky130_fd_sc_hd__or4_2
X_6104_ _1700_ _1699_ _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__a21oi_4
X_7084_ _2710_ _2736_ _2740_ VGND VGND VPWR VPWR _2741_ sky130_fd_sc_hd__a21o_2
X_6035_ _1692_ _1693_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__nand2_4
Xrebuffer10 _2250_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7986_ _0595_ _3638_ _3116_ VGND VGND VPWR VPWR _3639_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6937_ _0534_ _2593_ VGND VGND VPWR VPWR _2594_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6868_ _2405_ _2524_ _2522_ VGND VGND VPWR VPWR _2525_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_36_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8607_ net226 _4094_ VGND VGND VPWR VPWR _4103_ sky130_fd_sc_hd__and2_1
X_5819_ _1467_ _1472_ _1477_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__or3b_1
XFILLER_0_106_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6799_ _2455_ _2420_ VGND VGND VPWR VPWR _2456_ sky130_fd_sc_hd__or2_2
X_8538_ _4070_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8469_ _4046_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_9_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7840_ _0556_ _3334_ _3491_ _3492_ VGND VGND VPWR VPWR _3493_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_62_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4983_ display.refresh_counter\[19\] _0614_ display.refresh_counter\[17\] VGND VGND
+ VPWR VPWR _0642_ sky130_fd_sc_hd__and3_2
X_7771_ _3414_ _3421_ VGND VGND VPWR VPWR _3424_ sky130_fd_sc_hd__and2_1
X_6722_ _2243_ VGND VGND VPWR VPWR _2379_ sky130_fd_sc_hd__inv_2
X_6653_ _2301_ _2307_ _2309_ _2310_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_12_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5604_ _1262_ _0634_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__nand2_1
X_6584_ _0647_ _2099_ VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5535_ _1125_ _1193_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__xnor2_1
X_8323_ _3327_ _0813_ _0614_ VGND VGND VPWR VPWR _3969_ sky130_fd_sc_hd__or3b_1
X_8254_ _2124_ _3906_ VGND VGND VPWR VPWR _3907_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5466_ _1012_ _1124_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_41_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4417_ _4224_ _4225_ VGND VGND VPWR VPWR _4226_ sky130_fd_sc_hd__or2_1
X_7205_ _2829_ _2830_ VGND VGND VPWR VPWR _2862_ sky130_fd_sc_hd__nor2_1
X_8185_ _3776_ net98 _3765_ VGND VGND VPWR VPWR _3838_ sky130_fd_sc_hd__a21oi_1
X_5397_ net17 _0627_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__nor2_1
X_7136_ _2755_ _2779_ _2750_ VGND VGND VPWR VPWR _2793_ sky130_fd_sc_hd__a21oi_1
X_4348_ _4156_ VGND VGND VPWR VPWR _4157_ sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_21_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7067_ _2696_ _2698_ VGND VGND VPWR VPWR _2724_ sky130_fd_sc_hd__and2_1
XFILLER_0_94_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6018_ _1676_ _1578_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7969_ _3620_ _3621_ VGND VGND VPWR VPWR _3622_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5320_ _0977_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__xor2_1
XFILLER_0_23_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5251_ _0906_ _0907_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__o21a_2
XFILLER_0_48_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5182_ _0633_ _0776_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7823_ _3464_ _3475_ VGND VGND VPWR VPWR _3476_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7754_ _3396_ _3406_ _3399_ VGND VGND VPWR VPWR _3407_ sky130_fd_sc_hd__mux2_1
X_6705_ _2356_ _2361_ VGND VGND VPWR VPWR _2362_ sky130_fd_sc_hd__nor2b_1
XFILLER_0_58_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4966_ _0624_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4897_ _0285_ _4325_ _0283_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nand3_1
X_7685_ _3338_ VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_6
X_6636_ _2178_ _2293_ VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6567_ _0639_ _2147_ _2154_ _2225_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_6_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8306_ _3808_ _3958_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__xnor2_1
X_5518_ _1127_ _1128_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__xor2_1
X_6498_ _2129_ _2144_ _2156_ VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__and3_1
XFILLER_0_100_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8237_ _3689_ _3879_ VGND VGND VPWR VPWR _3890_ sky130_fd_sc_hd__or2_1
X_5449_ _1035_ _1107_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__or2_1
X_8168_ _1052_ _3817_ _3820_ _3709_ VGND VGND VPWR VPWR _3821_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_1_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7119_ _2710_ _2736_ _2775_ VGND VGND VPWR VPWR _2776_ sky130_fd_sc_hd__o21ai_1
X_8099_ _2339_ _2384_ _3751_ VGND VGND VPWR VPWR _3752_ sky130_fd_sc_hd__o21a_1
XFILLER_0_96_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4820_ _0460_ _0462_ _0369_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4751_ _0441_ _0444_ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_99_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7470_ _0388_ _3124_ VGND VGND VPWR VPWR _3125_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4682_ rf.registers\[25\]\[29\] _4167_ _4177_ rf.registers\[10\]\[29\] VGND VGND
+ VPWR VPWR _0379_ sky130_fd_sc_hd__a22o_1
X_6421_ _2079_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__inv_2
X_6352_ _1857_ _2007_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6283_ _1804_ _1782_ _1794_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__and3_1
X_5303_ _0910_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8022_ _3673_ _3674_ VGND VGND VPWR VPWR _3675_ sky130_fd_sc_hd__nand2_2
XFILLER_0_11_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5234_ _0886_ _0879_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__a21oi_4
X_5165_ _0799_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5096_ _0619_ _0750_ _0751_ _0752_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__a32o_1
X_8855_ clknet_4_0_0_clk _0017_ VGND VGND VPWR VPWR display.refresh_counter\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7806_ _3448_ _3454_ VGND VGND VPWR VPWR _3459_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8786_ clknet_4_11_0_clk _0160_ VGND VGND VPWR VPWR rf.registers\[10\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5998_ _1294_ _1621_ _1616_ _1597_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__a211o_1
X_4949_ _4197_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7737_ _3341_ _3122_ _3389_ VGND VGND VPWR VPWR _3390_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7668_ _3317_ _3322_ VGND VGND VPWR VPWR _3323_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_104_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6619_ _2262_ _2273_ _2275_ _2276_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__o211a_1
XFILLER_0_61_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7599_ net65 _3241_ _3245_ VGND VGND VPWR VPWR _3254_ sky130_fd_sc_hd__or3_1
XFILLER_0_104_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_594 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6970_ _2608_ _2624_ _2626_ VGND VGND VPWR VPWR _2627_ sky130_fd_sc_hd__a21o_2
X_5921_ net74 _1579_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8640_ net180 _4119_ VGND VGND VPWR VPWR _4121_ sky130_fd_sc_hd__and2_1
X_5852_ _1398_ _1510_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8571_ _4084_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4803_ net27 VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5783_ _1294_ _1435_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7522_ net24 _3176_ _3171_ VGND VGND VPWR VPWR _3177_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4734_ _4247_ _4246_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__nor2_1
X_7453_ _2395_ _3097_ VGND VGND VPWR VPWR _3109_ sky130_fd_sc_hd__xnor2_1
X_4665_ _0359_ _0361_ _4186_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7384_ net38 _3018_ VGND VGND VPWR VPWR _3041_ sky130_fd_sc_hd__nand2_1
X_6404_ _1971_ _1974_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__xnor2_1
X_4596_ _4314_ _0290_ _0292_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__a21o_1
XFILLER_0_101_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6335_ _1990_ _1993_ _1865_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8005_ _3089_ _3114_ _3115_ _3657_ _3113_ VGND VGND VPWR VPWR _3658_ sky130_fd_sc_hd__a311oi_2
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6266_ _1913_ _1916_ _1924_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__or3b_1
X_6197_ _1439_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__buf_4
X_5217_ net19 VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__inv_2
XFILLER_0_98_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5148_ net20 VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__inv_2
XFILLER_0_98_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5079_ net101 _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_55_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8838_ clknet_4_2_0_clk _0212_ VGND VGND VPWR VPWR rf.registers\[5\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_8769_ clknet_4_7_0_clk _0143_ _0042_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_94_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4450_ _4253_ _4258_ VGND VGND VPWR VPWR _4259_ sky130_fd_sc_hd__or2_1
X_4381_ _4182_ _4186_ _4189_ VGND VGND VPWR VPWR _4190_ sky130_fd_sc_hd__or3_1
X_6120_ _1776_ _1778_ _1694_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__mux2_4
XFILLER_0_0_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6051_ _1486_ _1706_ _1707_ _1708_ _1709_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__o32ai_1
X_5002_ _0480_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__inv_2
XFILLER_0_88_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6953_ _2577_ _2576_ _2609_ _2575_ VGND VGND VPWR VPWR _2610_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_88_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6884_ _2405_ _2507_ _2522_ VGND VGND VPWR VPWR _2541_ sky130_fd_sc_hd__nand3_1
X_5904_ _0645_ _1562_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8623_ net189 _4108_ VGND VGND VPWR VPWR _4112_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5835_ _1407_ _1493_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8554_ _4075_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5766_ _1290_ _1291_ net100 VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_32_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4717_ _0365_ _4290_ _0335_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__mux2_1
X_8485_ _4054_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
X_7505_ _0505_ _3159_ VGND VGND VPWR VPWR _3160_ sky130_fd_sc_hd__or2_1
X_5697_ _0651_ _1349_ _1355_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7436_ _3018_ VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_4
X_4648_ _0340_ _0343_ _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1 _1953_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_1
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4579_ _4330_ _4332_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__xor2_1
X_7367_ _2988_ VGND VGND VPWR VPWR _3024_ sky130_fd_sc_hd__inv_2
X_6318_ _1937_ _1976_ _1900_ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__a21oi_1
X_7298_ _2917_ _2954_ VGND VGND VPWR VPWR _2955_ sky130_fd_sc_hd__or2_1
X_6249_ _1726_ _1769_ _1732_ _1907_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__or4b_2
XTAP_TAPCELL_ROW_68_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold90 rf.registers\[15\]\[29\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5620_ _1120_ _1278_ _1245_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_26_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5551_ _1107_ _1134_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__nor2_1
X_8270_ _3919_ _3898_ _3921_ _3922_ VGND VGND VPWR VPWR _3923_ sky130_fd_sc_hd__a211o_1
X_4502_ _4187_ _4208_ VGND VGND VPWR VPWR _4311_ sky130_fd_sc_hd__nor2_1
X_7221_ _2833_ _2877_ VGND VGND VPWR VPWR _2878_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5482_ _1140_ _1131_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__nor2_1
X_4433_ rf.registers\[5\]\[30\] _4149_ _4241_ rf.registers\[15\]\[30\] VGND VGND VPWR
+ VPWR _4242_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4364_ _4172_ VGND VGND VPWR VPWR _4173_ sky130_fd_sc_hd__clkbuf_4
X_7152_ _2786_ _2788_ _2784_ _2785_ _2789_ VGND VGND VPWR VPWR _2809_ sky130_fd_sc_hd__a2111oi_1
X_6103_ _1610_ _1760_ _1761_ _1652_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7083_ _2737_ _2739_ VGND VGND VPWR VPWR _2740_ sky130_fd_sc_hd__nor2_1
X_6034_ _1029_ _1570_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__or2_2
Xrebuffer11 _3708_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer44 _3719_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_1
X_7985_ _0595_ _2396_ VGND VGND VPWR VPWR _3638_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_65_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6936_ _2589_ _2592_ _2388_ VGND VGND VPWR VPWR _2593_ sky130_fd_sc_hd__a21o_1
XFILLER_0_64_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6867_ _2518_ VGND VGND VPWR VPWR _2524_ sky130_fd_sc_hd__buf_2
XFILLER_0_91_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6798_ net34 _2409_ VGND VGND VPWR VPWR _2455_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5818_ _1456_ _1473_ _1474_ _1476_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__a31o_1
X_8606_ _4102_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8537_ _4070_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__inv_2
X_5749_ _1262_ _0952_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8468_ net193 _4045_ VGND VGND VPWR VPWR _4046_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7419_ _3074_ _3075_ VGND VGND VPWR VPWR _3076_ sky130_fd_sc_hd__and2_1
X_8399_ net243 _0577_ _4008_ VGND VGND VPWR VPWR _4009_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_9_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4982_ _0631_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_62_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7770_ _3411_ _3422_ VGND VGND VPWR VPWR _3423_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_34_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6721_ _2230_ _2375_ VGND VGND VPWR VPWR _2378_ sky130_fd_sc_hd__nand2_1
X_6652_ _1679_ _2300_ _2306_ _2305_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5603_ net15 VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_42_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8322_ _3806_ _3960_ _3962_ _3968_ _3810_ VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__a221oi_1
X_6583_ _2108_ VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__inv_2
XFILLER_0_26_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5534_ _1184_ _1191_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__o21a_1
X_8253_ _3903_ _3905_ _3822_ VGND VGND VPWR VPWR _3906_ sky130_fd_sc_hd__mux2_4
X_5465_ _1037_ _1123_ net69 VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__mux2_2
X_8184_ _3830_ _3835_ _3836_ VGND VGND VPWR VPWR _3837_ sky130_fd_sc_hd__and3b_1
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4416_ rf.registers\[5\]\[20\] _4148_ _4174_ rf.registers\[15\]\[20\] VGND VGND VPWR
+ VPWR _4225_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7204_ _2821_ _2825_ VGND VGND VPWR VPWR _2861_ sky130_fd_sc_hd__nand2_1
X_5396_ _1012_ _1005_ _1054_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__and3_1
X_7135_ _2755_ _2750_ _2777_ VGND VGND VPWR VPWR _2792_ sky130_fd_sc_hd__and3_1
X_4347_ _4155_ VGND VGND VPWR VPWR _4156_ sky130_fd_sc_hd__clkbuf_4
X_7066_ _2401_ _2722_ VGND VGND VPWR VPWR _2723_ sky130_fd_sc_hd__xnor2_1
X_6017_ _0651_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__buf_6
X_7968_ _3618_ _3615_ VGND VGND VPWR VPWR _3621_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7899_ net67 _3341_ _3550_ _3551_ VGND VGND VPWR VPWR _3552_ sky130_fd_sc_hd__a22o_1
X_6919_ _2388_ _2557_ _2559_ VGND VGND VPWR VPWR _2576_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5250_ _0660_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5181_ _0657_ _0838_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7822_ _3466_ _3474_ VGND VGND VPWR VPWR _3475_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4965_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__inv_1
X_7753_ _3394_ _3395_ _3398_ VGND VGND VPWR VPWR _3406_ sky130_fd_sc_hd__o21a_1
X_6704_ _2359_ _2360_ VGND VGND VPWR VPWR _2361_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4896_ net12 VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__clkbuf_4
X_7684_ _3337_ VGND VGND VPWR VPWR _3338_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6635_ _2180_ _2288_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6566_ _2149_ _2152_ _2071_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8305_ _3810_ _3957_ VGND VGND VPWR VPWR _3958_ sky130_fd_sc_hd__and2b_1
X_5517_ _0643_ _1133_ _1135_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__and3_1
X_8236_ _3881_ _3882_ _3709_ VGND VGND VPWR VPWR _3889_ sky130_fd_sc_hd__a21o_1
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6497_ _2148_ _2155_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5448_ _1020_ _1106_ _1033_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__mux2_1
X_8167_ _3752_ _3819_ _3787_ VGND VGND VPWR VPWR _3820_ sky130_fd_sc_hd__mux2_1
X_5379_ _1035_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__or2_1
X_8098_ _3660_ _3749_ _3750_ VGND VGND VPWR VPWR _3751_ sky130_fd_sc_hd__or3_1
X_7118_ _2710_ _2736_ _2740_ _2709_ VGND VGND VPWR VPWR _2775_ sky130_fd_sc_hd__o2bb2a_1
X_7049_ _2673_ _2691_ VGND VGND VPWR VPWR _2706_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4750_ _4199_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4681_ _4178_ _0328_ _0372_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6420_ _1679_ _2078_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6351_ _1874_ _2009_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5302_ _0910_ _0939_ _0872_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__a21o_2
X_6282_ _1932_ _1936_ _1940_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__a21oi_1
X_8021_ _3671_ _3672_ _2287_ VGND VGND VPWR VPWR _3674_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5233_ _0890_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__or2_1
X_5164_ _0626_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5095_ _0753_ _0633_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__nand2_1
Xclone7 _1568_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_2
XFILLER_0_78_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8854_ clknet_4_0_0_clk _0016_ VGND VGND VPWR VPWR display.refresh_counter\[6\] sky130_fd_sc_hd__dfxtp_1
X_7805_ _3449_ _3451_ _3457_ VGND VGND VPWR VPWR _3458_ sky130_fd_sc_hd__o21ba_1
X_8785_ clknet_4_14_0_clk _0159_ VGND VGND VPWR VPWR rf.registers\[10\]\[1\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5997_ _1647_ _1651_ _1652_ _1655_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__o31a_1
X_4948_ _0610_ _0611_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__nor2_1
X_7736_ net30 _3332_ _3328_ _3388_ VGND VGND VPWR VPWR _3389_ sky130_fd_sc_hd__a22o_1
X_7667_ _0595_ _3319_ VGND VGND VPWR VPWR _3322_ sky130_fd_sc_hd__or2b_1
XFILLER_0_74_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4879_ _4193_ _0485_ _0511_ _0558_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__a311o_1
XFILLER_0_19_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6618_ _1970_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7598_ _3252_ VGND VGND VPWR VPWR _3253_ sky130_fd_sc_hd__inv_2
X_6549_ net40 VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8219_ _3728_ _3871_ VGND VGND VPWR VPWR _3872_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_72_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5920_ _1545_ _1527_ _1532_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__nand3_1
XFILLER_0_45_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5851_ _1354_ _1509_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_103_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8570_ net240 _4083_ VGND VGND VPWR VPWR _4084_ sky130_fd_sc_hd__and2_1
X_4802_ _0480_ _4157_ _0493_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__a21o_1
X_5782_ _1294_ _1435_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4733_ net31 VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__buf_4
X_7521_ _3173_ _3175_ _3169_ VGND VGND VPWR VPWR _3176_ sky130_fd_sc_hd__a21oi_2
X_7452_ _3106_ _3107_ VGND VGND VPWR VPWR _3108_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6403_ _1889_ _2061_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4664_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__inv_2
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7383_ _0632_ _3039_ VGND VGND VPWR VPWR _3040_ sky130_fd_sc_hd__xnor2_1
X_4595_ _4309_ _0291_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6334_ net114 net105 _1991_ _1992_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__a22oi_2
X_6265_ _1922_ _1923_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8004_ _2396_ _3089_ _3112_ VGND VGND VPWR VPWR _3657_ sky130_fd_sc_hd__and3_1
X_5216_ _0807_ _0618_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__nand2_1
X_6196_ _1854_ net90 _1837_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__and3_1
X_5147_ _0753_ _0618_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__nand2_1
X_5078_ _0716_ _0719_ _0692_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_55_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8837_ clknet_4_2_0_clk _0211_ VGND VGND VPWR VPWR rf.registers\[5\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_94_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8768_ clknet_4_6_0_clk _0142_ _0041_ VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_35_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7719_ net81 _3370_ _3371_ _3334_ net16 VGND VGND VPWR VPWR _3372_ sky130_fd_sc_hd__o32a_2
XFILLER_0_74_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8699_ clknet_4_13_0_clk _0073_ VGND VGND VPWR VPWR rf.registers\[25\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4380_ _4187_ _4188_ VGND VGND VPWR VPWR _4189_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6050_ net66 _0629_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5001_ _0657_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__nor2_4
XFILLER_0_88_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6952_ _2564_ _2569_ VGND VGND VPWR VPWR _2609_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6883_ _2388_ _2539_ VGND VGND VPWR VPWR _2540_ sky130_fd_sc_hd__nand2_1
X_5903_ _1559_ _1533_ _1561_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__o21a_1
X_8622_ _4111_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
X_5834_ net65 _0629_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8553_ net229 _4072_ VGND VGND VPWR VPWR _4075_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5765_ _1329_ _1339_ _1422_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8484_ net218 _4045_ VGND VGND VPWR VPWR _4054_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_60_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4716_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__inv_2
X_7504_ _3154_ _3156_ _3158_ VGND VGND VPWR VPWR _3159_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_32_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5696_ _1121_ _1350_ _1354_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__a21oi_1
X_7435_ _3077_ _3091_ VGND VGND VPWR VPWR _3092_ sky130_fd_sc_hd__or2_1
X_4647_ _4182_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__clkbuf_4
X_7366_ _2989_ _2993_ VGND VGND VPWR VPWR _3023_ sky130_fd_sc_hd__xnor2_1
X_4578_ _0230_ _0272_ _0274_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__a21oi_1
X_6317_ _1970_ _1904_ _1975_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__o21a_1
X_7297_ _2930_ _2940_ _2952_ _2953_ VGND VGND VPWR VPWR _2954_ sky130_fd_sc_hd__a31o_1
X_6248_ _1766_ _1768_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__nand2_1
X_6179_ net66 VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__inv_2
XFILLER_0_99_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_80_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold91 rf.registers\[15\]\[20\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold80 rf.registers\[10\]\[26\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_58_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5550_ _1207_ _1208_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__nor2_1
X_4501_ rf.registers\[25\]\[13\] _4165_ _4174_ rf.registers\[10\]\[13\] VGND VGND
+ VPWR VPWR _4310_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_13_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5481_ _1126_ _1129_ _1130_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__a21oi_1
X_7220_ _2863_ _2854_ VGND VGND VPWR VPWR _2877_ sky130_fd_sc_hd__nand2_1
X_4432_ _4177_ VGND VGND VPWR VPWR _4241_ sky130_fd_sc_hd__buf_4
X_4363_ _4171_ VGND VGND VPWR VPWR _4172_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7151_ _2391_ _2806_ _2807_ VGND VGND VPWR VPWR _2808_ sky130_fd_sc_hd__and3_1
X_6102_ _1643_ _1652_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7082_ _2696_ _2738_ VGND VGND VPWR VPWR _2739_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6033_ _1688_ _1682_ _1691_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__a21o_2
Xrebuffer12 net80 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_1
Xrebuffer45 _3704_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd1_1
X_7984_ _3634_ _3636_ _3116_ VGND VGND VPWR VPWR _3637_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6935_ _2590_ _2585_ _2591_ VGND VGND VPWR VPWR _2592_ sky130_fd_sc_hd__a21bo_4
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6866_ _2405_ _2522_ _2518_ VGND VGND VPWR VPWR _2523_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6797_ _2436_ _2453_ _2387_ VGND VGND VPWR VPWR _2454_ sky130_fd_sc_hd__a21o_2
XFILLER_0_8_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5817_ _1475_ _1456_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__nor2_1
X_8605_ net245 _4094_ VGND VGND VPWR VPWR _4102_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8536_ _4070_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__inv_2
X_5748_ _1406_ _0635_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__nand2_2
X_8467_ _4033_ VGND VGND VPWR VPWR _4045_ sky130_fd_sc_hd__clkbuf_2
X_5679_ _1295_ _1337_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__and2_1
X_7418_ _3043_ _3066_ VGND VGND VPWR VPWR _3075_ sky130_fd_sc_hd__xnor2_1
X_8398_ _4241_ VGND VGND VPWR VPWR _4008_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_9_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7349_ _2394_ _3000_ VGND VGND VPWR VPWR _3006_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput2 net2 VGND VGND VPWR VPWR an[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4981_ _0632_ _0639_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_62_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6720_ _2230_ _2375_ _2376_ VGND VGND VPWR VPWR _2377_ sky130_fd_sc_hd__a21oi_2
X_6651_ _2172_ _2290_ _2295_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__a21o_1
XFILLER_0_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6582_ _2234_ _2109_ _2182_ _2240_ VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__and4b_1
XTAP_TAPCELL_ROW_14_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5602_ _1167_ _0952_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_42_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8321_ _3961_ _3962_ _3958_ VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__a21boi_1
XFILLER_0_14_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5533_ _1035_ _1189_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__nand2_1
X_8252_ _3904_ _3701_ VGND VGND VPWR VPWR _3905_ sky130_fd_sc_hd__xor2_1
X_5464_ _1095_ _1122_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__nand2_1
X_8183_ _2230_ _3834_ VGND VGND VPWR VPWR _3836_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4415_ _4222_ _4223_ VGND VGND VPWR VPWR _4224_ sky130_fd_sc_hd__or2_1
X_7203_ _2392_ _2855_ VGND VGND VPWR VPWR _2860_ sky130_fd_sc_hd__and2_1
X_5395_ _1052_ _1053_ _0951_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__a21oi_1
X_4346_ _4150_ _4154_ VGND VGND VPWR VPWR _4155_ sky130_fd_sc_hd__nor2_2
X_7134_ _2784_ _2785_ _2790_ VGND VGND VPWR VPWR _2791_ sky130_fd_sc_hd__or3b_1
X_7065_ _2719_ _2720_ _2721_ _2718_ VGND VGND VPWR VPWR _2722_ sky130_fd_sc_hd__a22o_1
X_6016_ _1574_ _1674_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__nor2_1
X_7967_ _3340_ _3619_ _3614_ VGND VGND VPWR VPWR _3620_ sky130_fd_sc_hd__o21a_1
XFILLER_0_89_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7898_ net3 _3273_ net2 VGND VGND VPWR VPWR _3551_ sky130_fd_sc_hd__o21a_1
XFILLER_0_64_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6918_ _2571_ _2572_ _2573_ _2574_ VGND VGND VPWR VPWR _2575_ sky130_fd_sc_hd__a211o_1
XFILLER_0_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6849_ _2477_ _2505_ VGND VGND VPWR VPWR _2506_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8519_ _4069_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__inv_2
XFILLER_0_102_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5180_ _0657_ _0838_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7821_ _3467_ _3472_ _3469_ VGND VGND VPWR VPWR _3474_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_86_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4964_ display.refresh_counter\[17\] _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nor2_2
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7752_ _3386_ _3404_ VGND VGND VPWR VPWR _3405_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_106_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6703_ _2172_ _2358_ VGND VGND VPWR VPWR _2360_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4895_ _0570_ _0527_ _0572_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7683_ _3328_ VGND VGND VPWR VPWR _3337_ sky130_fd_sc_hd__inv_2
XFILLER_0_46_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6634_ _2286_ _2281_ _2291_ VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_61_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6565_ _1970_ _2223_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8304_ _3806_ _3956_ _3955_ VGND VGND VPWR VPWR _3957_ sky130_fd_sc_hd__or3_4
X_6496_ _2153_ _2154_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__nor2_1
X_5516_ _1137_ _1138_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__nand2_1
X_8235_ _3709_ _3881_ _3882_ _3887_ VGND VGND VPWR VPWR _3888_ sky130_fd_sc_hd__a31o_1
X_5447_ _1023_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8166_ _3814_ _3818_ VGND VGND VPWR VPWR _3819_ sky130_fd_sc_hd__nand2_1
X_5378_ _0947_ _1036_ _1033_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__mux2_1
X_8097_ _2354_ _3743_ _2340_ VGND VGND VPWR VPWR _3750_ sky130_fd_sc_hd__a21oi_1
X_7117_ _2764_ _2767_ _2772_ _2773_ VGND VGND VPWR VPWR _2774_ sky130_fd_sc_hd__o31a_2
X_7048_ _2390_ _2669_ VGND VGND VPWR VPWR _2705_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4680_ _0373_ _0375_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6350_ net114 _1960_ _2008_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_70_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_468 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5301_ _0906_ _0959_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_51_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6281_ _1888_ _1894_ _1938_ _1939_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__a31o_1
XFILLER_0_59_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8020_ _2287_ _3671_ _3672_ VGND VGND VPWR VPWR _3673_ sky130_fd_sc_hd__nand3_2
X_5232_ _0626_ _0884_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5163_ _0746_ _0821_ _0789_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__mux2_1
X_5094_ _0534_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__inv_2
Xclone8 _0940_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_2
XFILLER_0_78_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8853_ clknet_4_0_0_clk _0015_ VGND VGND VPWR VPWR display.refresh_counter\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_93_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7804_ _3453_ _3449_ _3451_ VGND VGND VPWR VPWR _3457_ sky130_fd_sc_hd__and3_1
X_8784_ clknet_4_11_0_clk _0158_ VGND VGND VPWR VPWR rf.registers\[10\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_5996_ _1638_ _1639_ _1385_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__a21o_1
X_4947_ imem.address\[2\] _4162_ net242 VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7735_ _0388_ _0428_ net34 VGND VGND VPWR VPWR _3388_ sky130_fd_sc_hd__o21a_1
X_7666_ net35 _3320_ VGND VGND VPWR VPWR _3321_ sky130_fd_sc_hd__or2_1
X_4878_ _0485_ _0510_ _0559_ _0357_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__o211a_1
XFILLER_0_62_614 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6617_ _2109_ _2233_ _2249_ _2274_ VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__a211o_1
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7597_ _0570_ _3251_ VGND VGND VPWR VPWR _3252_ sky130_fd_sc_hd__or2_1
X_6548_ _2124_ _2204_ _2206_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_18_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6479_ _1618_ _2130_ _2136_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__nand3_1
X_8218_ _3729_ _3867_ _3870_ VGND VGND VPWR VPWR _3871_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_72_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8149_ _3799_ _3801_ VGND VGND VPWR VPWR _3802_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_58_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_611 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_36_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_45_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5850_ _1397_ _1508_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_103_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5781_ _1439_ _1431_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__nand2_1
X_4801_ _4158_ _0482_ _0492_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4732_ _0388_ _4157_ _0427_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a21o_1
X_7520_ _0515_ _3162_ _3165_ _3174_ VGND VGND VPWR VPWR _3175_ sky130_fd_sc_hd__o31ai_2
X_7451_ _3075_ _3095_ VGND VGND VPWR VPWR _3107_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4663_ _4283_ _4278_ net59 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_54_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6402_ _2058_ _1964_ _2059_ _2060_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__o22a_1
XFILLER_0_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7382_ _3018_ _3031_ VGND VGND VPWR VPWR _3039_ sky130_fd_sc_hd__nand2_1
X_4594_ _4306_ _4308_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__or2_1
X_6333_ _1486_ _1989_ _1842_ _1844_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__o211ai_1
X_6264_ _1865_ _1917_ _1921_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__nand3_1
X_8003_ _2396_ _3637_ _3654_ _3655_ VGND VGND VPWR VPWR _3656_ sky130_fd_sc_hd__o2bb2a_1
X_5215_ _0808_ _0853_ _0854_ _0873_ _0807_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__o32a_1
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
X_6195_ _1712_ _1715_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_63_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5146_ _0800_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__nand2_1
X_5077_ _0735_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__buf_6
XFILLER_0_79_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8836_ clknet_4_2_0_clk _0210_ VGND VGND VPWR VPWR rf.registers\[5\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8767_ clknet_4_6_0_clk _0141_ _0040_ VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5979_ net70 _1637_ _1472_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7718_ _3338_ _3227_ _3334_ VGND VGND VPWR VPWR _3371_ sky130_fd_sc_hd__o21ai_1
X_8698_ clknet_4_13_0_clk _0072_ VGND VGND VPWR VPWR rf.registers\[25\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_7649_ _3300_ _3301_ _3303_ VGND VGND VPWR VPWR _3304_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5000_ _0614_ _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__nor2_2
X_6951_ _2389_ _2607_ VGND VGND VPWR VPWR _2608_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_52_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6882_ _2534_ _2538_ _2524_ VGND VGND VPWR VPWR _2539_ sky130_fd_sc_hd__mux2_1
X_5902_ _1450_ _1560_ _1533_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__or3b_1
X_8621_ rf.registers\[5\]\[2\] _4108_ VGND VGND VPWR VPWR _4111_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5833_ _0570_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__inv_2
X_8552_ _4074_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7503_ _3157_ _3149_ _3151_ VGND VGND VPWR VPWR _3158_ sky130_fd_sc_hd__mux2_1
X_5764_ _1422_ _1329_ _1339_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__and3_1
XFILLER_0_44_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8483_ _4053_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_60_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4715_ _0408_ _0410_ _4186_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5695_ _0635_ _1353_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__or2_1
X_7434_ _3072_ _3076_ _3065_ VGND VGND VPWR VPWR _3091_ sky130_fd_sc_hd__a21oi_1
X_4646_ _0341_ _0342_ _0339_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4577_ _0226_ _0273_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__or2_1
X_7365_ _3017_ _3021_ VGND VGND VPWR VPWR _3022_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6316_ _1971_ _1974_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__or2_1
X_7296_ _2919_ _2939_ VGND VGND VPWR VPWR _2953_ sky130_fd_sc_hd__and2_1
X_6247_ _1888_ _1894_ _1901_ _1905_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__nand4_1
X_6178_ _1820_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__buf_2
XFILLER_0_99_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5129_ _0787_ _0774_ _0626_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_68_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8819_ clknet_4_10_0_clk _0193_ VGND VGND VPWR VPWR rf.registers\[5\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_80_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold70 imem.address\[4\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 rf.registers\[25\]\[4\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 rf.registers\[5\]\[18\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_100_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4500_ _4306_ _4308_ VGND VGND VPWR VPWR _4309_ sky130_fd_sc_hd__nand2_1
X_5480_ _1075_ _1076_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_1 _4155_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4431_ _4179_ _4239_ VGND VGND VPWR VPWR _4240_ sky130_fd_sc_hd__nand2_1
X_4362_ _4170_ VGND VGND VPWR VPWR _4171_ sky130_fd_sc_hd__buf_2
X_7150_ _2765_ _2766_ _2747_ _2756_ _2779_ VGND VGND VPWR VPWR _2807_ sky130_fd_sc_hd__o2111ai_2
X_6101_ _1645_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__inv_2
X_7081_ _2708_ _2695_ VGND VGND VPWR VPWR _2738_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6032_ _0645_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__and2_1
Xrebuffer13 net84 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__clkbuf_1
Xrebuffer35 _3715_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlymetal6s2s_1
X_7983_ _3110_ _3635_ VGND VGND VPWR VPWR _3636_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_1_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6934_ _2590_ _2585_ _2555_ _2532_ VGND VGND VPWR VPWR _2591_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_37_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_536 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6865_ _2502_ _2503_ VGND VGND VPWR VPWR _2522_ sky130_fd_sc_hd__or2_1
X_8604_ _4101_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6796_ _2439_ _2441_ _2445_ _2449_ _2452_ VGND VGND VPWR VPWR _2453_ sky130_fd_sc_hd__a221o_1
X_5816_ _1252_ _1335_ _1392_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__o21a_1
XFILLER_0_8_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8535_ _4070_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5747_ net65 VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__inv_2
X_8466_ _4044_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
X_7417_ _3063_ _3073_ VGND VGND VPWR VPWR _3074_ sky130_fd_sc_hd__nor2_1
X_5678_ _1327_ _1336_ _1326_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__a21o_1
X_8397_ _4007_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
X_4629_ _4246_ _0324_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7348_ _2972_ _3003_ _3004_ VGND VGND VPWR VPWR _3005_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_9_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7279_ _2393_ _2916_ _2935_ VGND VGND VPWR VPWR _2936_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_67_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput3 net3 VGND VGND VPWR VPWR an[1] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4980_ _0638_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_62_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6650_ _2295_ _2301_ _2307_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__and3b_1
X_6581_ _2236_ _2237_ _0641_ _2239_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__nor4_1
XFILLER_0_6_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5601_ _1168_ _1258_ _1259_ _1167_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__o22a_1
X_8320_ _3807_ _3968_ _3964_ VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_14_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5532_ _0628_ _1182_ _1190_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_42_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8251_ net7 _3699_ _3700_ VGND VGND VPWR VPWR _3904_ sky130_fd_sc_hd__a21oi_1
X_5463_ _1044_ _1094_ _1039_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__o21ai_1
X_8182_ _2230_ _3834_ VGND VGND VPWR VPWR _3835_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4414_ rf.registers\[5\]\[19\] _4148_ _4174_ rf.registers\[15\]\[19\] VGND VGND VPWR
+ VPWR _4223_ sky130_fd_sc_hd__a22o_1
X_7202_ _2392_ _2858_ VGND VGND VPWR VPWR _2859_ sky130_fd_sc_hd__and2_1
X_5394_ _1024_ _1011_ _1030_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a21o_1
X_4345_ _4153_ VGND VGND VPWR VPWR _4154_ sky130_fd_sc_hd__buf_4
XFILLER_0_78_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7133_ _2786_ _2788_ _2789_ VGND VGND VPWR VPWR _2790_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7064_ _2696_ _2698_ _2712_ _2717_ VGND VGND VPWR VPWR _2721_ sky130_fd_sc_hd__a211o_1
XFILLER_0_94_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6015_ _0645_ _1673_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7966_ _3613_ _3616_ _3618_ VGND VGND VPWR VPWR _3619_ sky130_fd_sc_hd__o21a_1
X_7897_ _3348_ _1533_ _3329_ _3549_ VGND VGND VPWR VPWR _3550_ sky130_fd_sc_hd__a211o_1
X_6917_ _2526_ _2558_ _2529_ VGND VGND VPWR VPWR _2574_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6848_ _0515_ _2398_ _2476_ VGND VGND VPWR VPWR _2505_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8518_ _3995_ VGND VGND VPWR VPWR _4069_ sky130_fd_sc_hd__buf_4
X_6779_ _2417_ _2434_ _2435_ VGND VGND VPWR VPWR _2436_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_17_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8449_ net238 _4034_ VGND VGND VPWR VPWR _4036_ sky130_fd_sc_hd__or2b_1
XFILLER_0_32_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7820_ _3470_ _3467_ _3472_ VGND VGND VPWR VPWR _3473_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4963_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__buf_4
X_7751_ _3401_ _3403_ VGND VGND VPWR VPWR _3404_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_106_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6702_ _2172_ _2358_ VGND VGND VPWR VPWR _2359_ sky130_fd_sc_hd__nor2_1
X_7682_ _2296_ _3093_ _3119_ VGND VGND VPWR VPWR _3336_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_612 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6633_ _2287_ _2290_ VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__xnor2_1
X_4894_ _0550_ _0288_ _0571_ _0465_ _0469_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__a32o_1
XFILLER_0_6_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6564_ _2140_ _2141_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8303_ net10 _3342_ VGND VGND VPWR VPWR _3956_ sky130_fd_sc_hd__and2_1
X_6495_ _2071_ _2149_ _2152_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__and3_1
X_5515_ _1170_ _1164_ _1171_ _1172_ _1173_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_42_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8234_ _3884_ _3886_ net92 VGND VGND VPWR VPWR _3887_ sky130_fd_sc_hd__mux2_2
XFILLER_0_14_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5446_ _0722_ _1100_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8165_ _3753_ _3813_ VGND VGND VPWR VPWR _3818_ sky130_fd_sc_hd__nand2_1
X_5377_ _0948_ _1002_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__xnor2_1
X_8096_ _2340_ _2354_ _3743_ VGND VGND VPWR VPWR _3749_ sky130_fd_sc_hd__and3_1
X_7116_ _2770_ _2771_ _2390_ VGND VGND VPWR VPWR _2773_ sky130_fd_sc_hd__a21o_1
X_7047_ _0556_ _2402_ VGND VGND VPWR VPWR _2704_ sky130_fd_sc_hd__nand2_1
X_7949_ _3601_ _3596_ VGND VGND VPWR VPWR _3602_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5300_ _0874_ _0958_ _0940_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__mux2_4
XFILLER_0_11_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6280_ _1887_ _1893_ _1865_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_59_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5231_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__inv_2
X_5162_ _0747_ _0760_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__xor2_1
X_5093_ _0709_ _0618_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8852_ clknet_4_1_0_clk _0014_ VGND VGND VPWR VPWR display.refresh_counter\[4\] sky130_fd_sc_hd__dfxtp_1
X_7803_ _3446_ _3455_ VGND VGND VPWR VPWR _3456_ sky130_fd_sc_hd__xnor2_1
X_8783_ clknet_4_7_0_clk _0157_ _0056_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_93_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7734_ _3333_ _3127_ VGND VGND VPWR VPWR _3387_ sky130_fd_sc_hd__or2_1
XFILLER_0_47_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5995_ _1632_ _1646_ _1648_ _1653_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__and4_1
X_4946_ net137 _0610_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__xor2_1
X_7665_ _0595_ _3319_ VGND VGND VPWR VPWR _3320_ sky130_fd_sc_hd__xor2_1
X_4877_ _0445_ _0507_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6616_ _2204_ _2206_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7596_ net65 _3247_ _3245_ _3249_ VGND VGND VPWR VPWR _3251_ sky130_fd_sc_hd__a31o_1
X_6547_ net82 _2101_ _2205_ _2188_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6478_ _2136_ _2130_ _1618_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__a21o_1
X_8217_ _2302_ _3866_ VGND VGND VPWR VPWR _3870_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_72_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5429_ _0986_ _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__xnor2_1
X_8148_ _3625_ _3627_ _3800_ VGND VGND VPWR VPWR _3801_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_10_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8079_ _3708_ _3691_ net94 _3731_ VGND VGND VPWR VPWR _3732_ sky130_fd_sc_hd__a31oi_4
XTAP_TAPCELL_ROW_58_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4800_ _0358_ _0484_ _0487_ _0491_ _4193_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_103_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5780_ _1012_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__buf_4
XFILLER_0_83_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4731_ _0389_ _0391_ _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7450_ _3068_ _3098_ VGND VGND VPWR VPWR _3106_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4662_ _4275_ _4272_ net59 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6401_ _1901_ _1976_ _1964_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7381_ _3035_ _3037_ VGND VGND VPWR VPWR _3038_ sky130_fd_sc_hd__nand2_1
X_4593_ _4315_ _0289_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__nand2_1
X_6332_ net67 _0813_ _1795_ _1989_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__or4_1
XFILLER_0_3_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6263_ _1917_ _1921_ _1865_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8002_ net5 _3652_ VGND VGND VPWR VPWR _3655_ sky130_fd_sc_hd__and2_1
X_5214_ _0813_ _0872_ net88 VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__nor3_1
X_6194_ _1818_ _1837_ _1852_ _1718_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__a211oi_2
X_5145_ _0801_ _0803_ _0788_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__mux2_4
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5076_ _0734_ _0625_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_55_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8835_ clknet_4_2_0_clk _0209_ VGND VGND VPWR VPWR rf.registers\[5\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8766_ clknet_4_13_0_clk _0140_ _0039_ VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5978_ _1505_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__and2b_1
XFILLER_0_47_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4929_ _0595_ _4156_ _0598_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__a21o_1
X_8697_ clknet_4_13_0_clk _0071_ VGND VGND VPWR VPWR rf.registers\[25\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7717_ _3347_ _2724_ VGND VGND VPWR VPWR _3370_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7648_ _3293_ _3302_ VGND VGND VPWR VPWR _3303_ sky130_fd_sc_hd__and2_1
XFILLER_0_62_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7579_ net15 _3233_ VGND VGND VPWR VPWR _3234_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_604 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_592 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_0_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6950_ _2603_ _2604_ _2605_ _2606_ VGND VGND VPWR VPWR _2607_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_88_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5901_ _1119_ _1449_ _1445_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__and3_1
XFILLER_0_76_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6881_ _2536_ _2537_ VGND VGND VPWR VPWR _2538_ sky130_fd_sc_hd__xnor2_1
X_8620_ _4110_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5832_ _1484_ _1490_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__xnor2_1
X_8551_ net143 _4072_ VGND VGND VPWR VPWR _4074_ sky130_fd_sc_hd__or2b_1
XFILLER_0_29_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5763_ _1292_ _1293_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__or2_1
X_4714_ _0409_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7502_ _3149_ _3147_ VGND VGND VPWR VPWR _3157_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8482_ net199 _4045_ VGND VGND VPWR VPWR _4053_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_60_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5694_ _1343_ _1352_ _1334_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__mux2_4
XTAP_TAPCELL_ROW_32_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7433_ _3064_ VGND VGND VPWR VPWR _3090_ sky130_fd_sc_hd__inv_2
X_4645_ _4330_ _4326_ _0335_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4576_ _0223_ _0225_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__and2_1
X_7364_ _3018_ _3020_ VGND VGND VPWR VPWR _3021_ sky130_fd_sc_hd__xnor2_1
Xfanout4 _0644_ VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_1
X_6315_ _1972_ _1925_ _1930_ _1973_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__o31a_1
X_7295_ _2926_ _2929_ _2921_ VGND VGND VPWR VPWR _2952_ sky130_fd_sc_hd__o21ai_1
X_6246_ _1856_ _1904_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__xnor2_1
X_6177_ _1835_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__inv_2
XFILLER_0_99_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5128_ _0779_ _0777_ _0780_ _0784_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__a311o_1
XFILLER_0_98_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5059_ _0681_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8818_ clknet_4_9_0_clk _0192_ VGND VGND VPWR VPWR rf.registers\[5\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8749_ clknet_4_3_0_clk _0123_ VGND VGND VPWR VPWR rf.registers\[15\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold71 rf.registers\[15\]\[3\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 rf.registers\[5\]\[19\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 display.refresh_counter\[15\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 rf.registers\[5\]\[10\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_82_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_81_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_2 reset VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4430_ _4236_ _4237_ _4238_ VGND VGND VPWR VPWR _4239_ sky130_fd_sc_hd__or3_2
XPHY_EDGE_ROW_91_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4361_ _4168_ _4169_ VGND VGND VPWR VPWR _4170_ sky130_fd_sc_hd__nor2_1
X_6100_ _1741_ _1746_ _1753_ _1758_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__nand4_1
XFILLER_0_21_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7080_ _2694_ _2698_ VGND VGND VPWR VPWR _2737_ sky130_fd_sc_hd__and2b_1
X_6031_ _1020_ _1683_ _1689_ _0925_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__a211o_1
XFILLER_0_83_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer36 net102 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_1
X_7982_ _3105_ _3108_ _3109_ VGND VGND VPWR VPWR _3635_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_1_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6933_ _2400_ _2532_ VGND VGND VPWR VPWR _2590_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_37_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6864_ _2405_ _2518_ _2404_ _2519_ _2520_ VGND VGND VPWR VPWR _2521_ sky130_fd_sc_hd__a311o_1
XFILLER_0_76_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5815_ _1387_ _1417_ _1419_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__a21o_1
X_8603_ net147 _4094_ VGND VGND VPWR VPWR _4101_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6795_ _2450_ _2451_ VGND VGND VPWR VPWR _2452_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5746_ net15 _1404_ net71 VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__mux2_1
X_8534_ _4070_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__inv_2
X_8465_ net151 _4034_ VGND VGND VPWR VPWR _4044_ sky130_fd_sc_hd__and2_1
X_5677_ _1249_ _1286_ _1305_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7416_ _3037_ _3062_ VGND VGND VPWR VPWR _3073_ sky130_fd_sc_hd__nor2_1
X_4628_ _4178_ _4243_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8396_ net231 _0580_ _3997_ VGND VGND VPWR VPWR _4007_ sky130_fd_sc_hd__mux2_1
X_4559_ _4188_ _0255_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_77_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7347_ _2972_ _2977_ _3001_ VGND VGND VPWR VPWR _3004_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_9_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7278_ _2920_ _2930_ _2934_ VGND VGND VPWR VPWR _2935_ sky130_fd_sc_hd__a21o_1
X_6229_ _1676_ _1887_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_55_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput4 net4 VGND VGND VPWR VPWR an[2] sky130_fd_sc_hd__buf_2
XFILLER_0_37_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6580_ net38 net37 net36 _2238_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__or4_1
XFILLER_0_73_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5600_ _1214_ _1220_ _0628_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_14_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5531_ _1035_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_42_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8250_ _3699_ VGND VGND VPWR VPWR _3903_ sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_26_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5462_ _1120_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__buf_4
XFILLER_0_41_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7201_ _2848_ _2857_ _2854_ VGND VGND VPWR VPWR _2858_ sky130_fd_sc_hd__mux2_1
X_8181_ _3735_ _3833_ _3787_ VGND VGND VPWR VPWR _3834_ sky130_fd_sc_hd__mux2_2
X_4413_ _4220_ _4221_ VGND VGND VPWR VPWR _4222_ sky130_fd_sc_hd__or2_1
X_5393_ _0655_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__buf_4
XFILLER_0_1_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4344_ net1 _4152_ VGND VGND VPWR VPWR _4153_ sky130_fd_sc_hd__and2_1
X_7132_ _2755_ _2779_ VGND VGND VPWR VPWR _2789_ sky130_fd_sc_hd__and2_1
X_7063_ _2696_ _2698_ _2712_ VGND VGND VPWR VPWR _2720_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6014_ _1557_ _1672_ net74 VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7965_ _3610_ _3617_ _3607_ VGND VGND VPWR VPWR _3618_ sky130_fd_sc_hd__mux2_1
X_7896_ _3348_ _2911_ VGND VGND VPWR VPWR _3549_ sky130_fd_sc_hd__nor2_1
X_6916_ _2526_ _2529_ _2556_ VGND VGND VPWR VPWR _2573_ sky130_fd_sc_hd__and3_1
XFILLER_0_76_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6847_ _2476_ VGND VGND VPWR VPWR _2504_ sky130_fd_sc_hd__inv_2
XFILLER_0_91_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6778_ _2422_ _2428_ _2429_ VGND VGND VPWR VPWR _2435_ sky130_fd_sc_hd__or3_1
X_8517_ _3996_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__inv_2
X_5729_ _1253_ _1375_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__nor2_1
X_8448_ _4035_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8379_ _3998_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer5 _2292_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_63_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4962_ display.refresh_counter\[18\] display.refresh_counter\[19\] VGND VGND VPWR
+ VPWR _0621_ sky130_fd_sc_hd__nand2b_1
X_7750_ _3395_ _3400_ VGND VGND VPWR VPWR _3403_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_106_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7681_ net32 _3330_ net2 VGND VGND VPWR VPWR _3335_ sky130_fd_sc_hd__mux2_1
X_6701_ _2147_ _2357_ _2283_ VGND VGND VPWR VPWR _2358_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4893_ _4322_ _0286_ _0287_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__nand3_1
X_6632_ _2180_ _2289_ VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_80_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6563_ _2124_ _2122_ _2221_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8302_ _3951_ net3 _3954_ _3342_ VGND VGND VPWR VPWR _3955_ sky130_fd_sc_hd__a211oi_2
X_6494_ _2149_ _2152_ _2071_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__a21oi_1
X_5514_ _0971_ _1156_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__xnor2_1
X_8233_ _3675_ _3885_ VGND VGND VPWR VPWR _3886_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5445_ _0660_ _1103_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8164_ _3747_ _3811_ _3816_ _3815_ VGND VGND VPWR VPWR _3817_ sky130_fd_sc_hd__a22o_1
XFILLER_0_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5376_ _0906_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__buf_4
X_7115_ _2390_ _2770_ _2771_ VGND VGND VPWR VPWR _2772_ sky130_fd_sc_hd__and3_1
X_8095_ _2124_ _3747_ VGND VGND VPWR VPWR _3748_ sky130_fd_sc_hd__xnor2_1
X_7046_ _2700_ _2701_ _0954_ _2702_ VGND VGND VPWR VPWR _2703_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_96_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7948_ _3597_ _3600_ VGND VGND VPWR VPWR _3601_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7879_ _3518_ _3525_ VGND VGND VPWR VPWR _3532_ sky130_fd_sc_hd__xor2_1
XFILLER_0_20_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold190 rf.registers\[25\]\[29\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5230_ _0825_ net81 _0887_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a31o_1
XFILLER_0_59_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5161_ _0817_ _0810_ _0818_ _0819_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__a211o_1
X_5092_ _0625_ _0734_ _0709_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8851_ clknet_4_1_0_clk _0013_ VGND VGND VPWR VPWR display.refresh_counter\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8782_ clknet_4_5_0_clk _0156_ _0055_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dfrtp_4
X_7802_ _3448_ _3454_ VGND VGND VPWR VPWR _3455_ sky130_fd_sc_hd__nor2_1
X_5994_ _1651_ _1652_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__nor2_1
X_4945_ imem.address\[3\] imem.address\[2\] _4162_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__and3_1
XFILLER_0_59_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7733_ _3337_ _3136_ _0480_ _3341_ VGND VGND VPWR VPWR _3386_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_47_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7664_ _3310_ _3318_ VGND VGND VPWR VPWR _3319_ sky130_fd_sc_hd__or2b_1
X_4876_ _4305_ _0296_ _0297_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__o31a_1
X_6615_ _2237_ _2213_ VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7595_ _3241_ _3249_ VGND VGND VPWR VPWR _3250_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6546_ net40 _0813_ _1795_ _2187_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__or4b_1
X_6477_ _2101_ _2100_ _2134_ _2135_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__a22o_1
X_8216_ _3866_ _3868_ _3822_ VGND VGND VPWR VPWR _3869_ sky130_fd_sc_hd__mux2_4
X_5428_ _1074_ _0980_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__and2_1
XFILLER_0_100_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8147_ _3335_ _3628_ _3623_ VGND VGND VPWR VPWR _3800_ sky130_fd_sc_hd__o21a_1
XFILLER_0_10_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5359_ _0920_ _1014_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__nor2_1
X_8078_ _3727_ _3730_ net97 VGND VGND VPWR VPWR _3731_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7029_ _2680_ _2668_ _2684_ VGND VGND VPWR VPWR _2686_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_58_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_476 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_524 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_103_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4730_ _4193_ _0406_ _0425_ _0358_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__a22o_1
X_4661_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__buf_2
XFILLER_0_16_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7380_ _3011_ _3036_ VGND VGND VPWR VPWR _3037_ sky130_fd_sc_hd__xnor2_1
X_6400_ _1901_ _1976_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6331_ _1952_ _1989_ _1960_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__and3_1
X_4592_ _4316_ _4318_ _0288_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_12_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6262_ _1818_ _1837_ _1919_ _1920_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__a211o_1
XFILLER_0_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8001_ _3651_ _3653_ VGND VGND VPWR VPWR _3654_ sky130_fd_sc_hd__nor2_1
X_6193_ _1716_ _1717_ _1710_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__a21oi_1
X_5213_ _0622_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__buf_4
X_5144_ _0802_ _0755_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__xor2_1
XFILLER_0_19_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5075_ _0732_ _0685_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8834_ clknet_4_2_0_clk _0208_ VGND VGND VPWR VPWR rf.registers\[5\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8765_ clknet_4_7_0_clk _0139_ _0038_ VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__dfrtp_2
X_5977_ _1462_ _1635_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__or2_1
X_4928_ _0464_ net57 _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__a21o_1
X_8696_ clknet_4_13_0_clk _0070_ VGND VGND VPWR VPWR rf.registers\[25\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_7716_ _1262_ _3341_ _3367_ _3368_ VGND VGND VPWR VPWR _3369_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7647_ _3291_ _3295_ _3292_ VGND VGND VPWR VPWR _3302_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_74_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4859_ _0540_ _0541_ _0543_ _4158_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a22o_1
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7578_ _3231_ _3232_ VGND VGND VPWR VPWR _3233_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6529_ _0620_ _2187_ _1999_ _2000_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__a211o_1
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_616 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5900_ _1448_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__inv_2
XFILLER_0_72_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6880_ _2508_ _2513_ VGND VGND VPWR VPWR _2537_ sky130_fd_sc_hd__nor2_1
X_5831_ _1485_ _1489_ _1455_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__mux2_1
X_8550_ _4073_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5762_ _1420_ _1402_ _1417_ _1400_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__or4_4
XPHY_EDGE_ROW_101_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4713_ _4286_ _4283_ net59 VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__mux2_1
X_7501_ _3148_ _3155_ VGND VGND VPWR VPWR _3156_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8481_ _4052_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_60_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5693_ _1238_ _1351_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_32_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7432_ _3060_ _3080_ _3088_ VGND VGND VPWR VPWR _3089_ sky130_fd_sc_hd__mux2_1
X_4644_ _4324_ _4319_ _0335_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4575_ _0236_ _0269_ _0271_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__a21o_1
X_7363_ _2993_ _3003_ _3019_ VGND VGND VPWR VPWR _3020_ sky130_fd_sc_hd__a21oi_1
X_6314_ _1936_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__inv_2
X_7294_ _2917_ _2950_ VGND VGND VPWR VPWR _2951_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6245_ _1757_ _1822_ _1902_ _1903_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__o22a_2
X_6176_ _0646_ _1834_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__nor2_1
X_5127_ _0773_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__or2_1
XFILLER_0_98_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5058_ _0661_ _0680_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8817_ clknet_4_10_0_clk _0191_ VGND VGND VPWR VPWR rf.registers\[5\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_80_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8748_ clknet_4_1_0_clk _0122_ VGND VGND VPWR VPWR rf.registers\[15\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_105_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8679_ net182 _4107_ VGND VGND VPWR VPWR _4141_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold50 _3987_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 rf.registers\[10\]\[3\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold61 display.refresh_counter\[6\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 rf.registers\[5\]\[23\] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 rf.registers\[10\]\[21\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_3 _1264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4360_ imem.address\[0\] _4143_ VGND VGND VPWR VPWR _4169_ sky130_fd_sc_hd__or2b_1
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6030_ _1294_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__buf_4
Xrebuffer26 _3786_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dlymetal6s2s_1
X_7981_ _3097_ VGND VGND VPWR VPWR _3634_ sky130_fd_sc_hd__inv_2
XFILLER_0_83_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer37 net102 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlygate4sd1_1
XTAP_TAPCELL_ROW_65_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6932_ _2561_ _2578_ _2584_ _2588_ VGND VGND VPWR VPWR _2589_ sky130_fd_sc_hd__a211o_2
XTAP_TAPCELL_ROW_37_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6863_ _0709_ _2399_ VGND VGND VPWR VPWR _2520_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5814_ _1387_ _1417_ _1419_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__nand3_1
X_8602_ _4100_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
X_6794_ _2428_ _2432_ _2422_ VGND VGND VPWR VPWR _2451_ sky130_fd_sc_hd__o21a_1
XFILLER_0_106_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5745_ _1263_ _1403_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__nand2_1
X_8533_ _4070_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__inv_2
XFILLER_0_96_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8464_ _4043_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5676_ net71 VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__buf_6
XFILLER_0_44_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7415_ _3068_ _3069_ _3071_ VGND VGND VPWR VPWR _3072_ sky130_fd_sc_hd__nand3b_1
X_4627_ _4247_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__nor2_1
X_8395_ _4006_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4558_ rf.registers\[25\]\[0\] _4164_ _4171_ rf.registers\[10\]\[0\] VGND VGND VPWR
+ VPWR _0255_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_77_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7346_ _3000_ VGND VGND VPWR VPWR _3003_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_9_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4489_ _4292_ _4296_ VGND VGND VPWR VPWR _4298_ sky130_fd_sc_hd__and2_1
X_7277_ _2393_ _2933_ VGND VGND VPWR VPWR _2934_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6228_ _1740_ _1886_ _1822_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__mux2_2
X_6159_ _1815_ _1805_ _1817_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__a21o_4
XFILLER_0_99_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput5 net5 VGND VGND VPWR VPWR an[3] sky130_fd_sc_hd__clkbuf_4
Xoutput40 net40 VGND VGND VPWR VPWR result[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5530_ _1043_ _1188_ net69 VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5461_ _1035_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__buf_4
XFILLER_0_26_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4412_ rf.registers\[5\]\[18\] _4148_ _4174_ rf.registers\[15\]\[18\] VGND VGND VPWR
+ VPWR _4221_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7200_ _2849_ _2835_ _2856_ VGND VGND VPWR VPWR _2857_ sky130_fd_sc_hd__o21bai_1
X_8180_ _3831_ _3832_ VGND VGND VPWR VPWR _3833_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5392_ _1012_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4343_ imem.address\[4\] imem.address\[3\] _4151_ VGND VGND VPWR VPWR _4152_ sky130_fd_sc_hd__nor3_1
XFILLER_0_10_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7131_ net64 _2402_ _2787_ VGND VGND VPWR VPWR _2788_ sky130_fd_sc_hd__a21o_1
X_7062_ _2717_ _2718_ VGND VGND VPWR VPWR _2719_ sky130_fd_sc_hd__nor2_1
X_6013_ _1670_ _1671_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__or2_1
XFILLER_0_94_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7964_ _3608_ _3610_ VGND VGND VPWR VPWR _3617_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6915_ _2565_ _2558_ _2570_ VGND VGND VPWR VPWR _2572_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7895_ _3542_ _3543_ _3547_ VGND VGND VPWR VPWR _3548_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6846_ _0515_ _2398_ _2489_ VGND VGND VPWR VPWR _2503_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6777_ _2422_ _2428_ _2433_ VGND VGND VPWR VPWR _2434_ sky130_fd_sc_hd__or3_1
X_8516_ _3996_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__inv_2
XFILLER_0_91_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5728_ _1256_ _1372_ _1386_ _1275_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__a211o_1
X_8447_ rf.registers\[15\]\[0\] _4034_ VGND VGND VPWR VPWR _4035_ sky130_fd_sc_hd__or2b_1
X_5659_ _0388_ _0726_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8378_ net230 _0609_ _3997_ VGND VGND VPWR VPWR _3998_ sky130_fd_sc_hd__mux2_1
X_7329_ _2962_ _2968_ VGND VGND VPWR VPWR _2986_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_68_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer6 net72 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_63_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4961_ _0620_ VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_106_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6700_ _2148_ _2219_ VGND VGND VPWR VPWR _2357_ sky130_fd_sc_hd__xnor2_1
X_4892_ net13 VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__buf_6
X_7680_ _3334_ VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_104_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6631_ _2288_ _2262_ VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8301_ _3320_ _3791_ _3953_ _3795_ net3 VGND VGND VPWR VPWR _3954_ sky130_fd_sc_hd__a2111oi_1
XFILLER_0_89_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6562_ _2071_ _2127_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6493_ net82 _2101_ _2151_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__a21o_1
X_5513_ _1035_ _1163_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__and2_1
X_8232_ _3679_ _3880_ VGND VGND VPWR VPWR _3885_ sky130_fd_sc_hd__nand2_1
X_5444_ _1016_ _1033_ _1102_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__o21a_1
X_8163_ _3814_ _3775_ _3748_ _3811_ VGND VGND VPWR VPWR _3816_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_74_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5375_ _0942_ _1004_ _1033_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__mux2_1
X_7114_ _2733_ _2744_ _2769_ _2741_ VGND VGND VPWR VPWR _2771_ sky130_fd_sc_hd__nand4_1
X_8094_ _2384_ _3745_ _3746_ VGND VGND VPWR VPWR _3747_ sky130_fd_sc_hd__a21oi_2
X_7045_ _2696_ _2698_ VGND VGND VPWR VPWR _2702_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7947_ _3591_ _3584_ VGND VGND VPWR VPWR _3600_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7878_ _3528_ _3530_ VGND VGND VPWR VPWR _3531_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6829_ _2485_ VGND VGND VPWR VPWR _2486_ sky130_fd_sc_hd__inv_2
XFILLER_0_92_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold180 rf.registers\[10\]\[13\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
Xhold191 rf.registers\[25\]\[14\] VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5160_ _0657_ _0816_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__and2_4
X_5091_ _0709_ _0625_ _0734_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__or3_1
XFILLER_0_78_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8850_ clknet_4_1_0_clk net121 VGND VGND VPWR VPWR display.refresh_counter\[2\] sky130_fd_sc_hd__dfxtp_1
X_8781_ clknet_4_5_0_clk _0155_ _0054_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dfrtp_1
X_7801_ _3450_ _3451_ _3453_ VGND VGND VPWR VPWR _3454_ sky130_fd_sc_hd__a21oi_1
X_5993_ _1641_ _1484_ _1642_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__and3_1
X_4944_ net250 _4160_ _0390_ _0609_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__a31o_1
X_7732_ _0505_ _3384_ _3333_ VGND VGND VPWR VPWR _3385_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7663_ _3311_ _3316_ _3317_ VGND VGND VPWR VPWR _3318_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4875_ _4168_ _0298_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6614_ _2269_ _2271_ _2250_ VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__mux2_4
XFILLER_0_6_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7594_ net65 _3248_ VGND VGND VPWR VPWR _3249_ sky130_fd_sc_hd__nor2_1
X_6545_ _2187_ net87 _2095_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__or3_1
XFILLER_0_27_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8215_ _3729_ _3867_ VGND VGND VPWR VPWR _3868_ sky130_fd_sc_hd__xnor2_1
X_6476_ _2055_ _2133_ _2040_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__o21ai_1
X_5427_ _0983_ _0984_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__nor2_1
X_8146_ _3629_ _3798_ VGND VGND VPWR VPWR _3799_ sky130_fd_sc_hd__and2_1
X_5358_ _1012_ _1016_ _0722_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__o21a_1
X_8077_ _3728_ _3729_ VGND VGND VPWR VPWR _3730_ sky130_fd_sc_hd__and2b_1
X_5289_ _0627_ _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__xnor2_2
X_7028_ _2680_ _2684_ _2667_ VGND VGND VPWR VPWR _2685_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_103_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4660_ _4160_ _4194_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__nor2_2
XFILLER_0_56_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4591_ _4322_ _0286_ _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__a21o_1
X_6330_ _1840_ _1841_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_23_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6261_ _1918_ _1909_ _1774_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__a21oi_1
X_8000_ net5 _3652_ VGND VGND VPWR VPWR _3653_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_71_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6192_ _1676_ _1847_ _1850_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__and3_1
X_5212_ _0649_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5143_ _0759_ _0749_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__and2b_1
XFILLER_0_19_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5074_ _0656_ _0684_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__nor2_1
X_8833_ clknet_4_8_0_clk _0207_ VGND VGND VPWR VPWR rf.registers\[5\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8764_ clknet_4_7_0_clk _0138_ _0037_ VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5976_ _1477_ _1634_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__nand2_1
X_4927_ _4154_ _0266_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__and3_1
X_8695_ clknet_4_13_0_clk _0069_ VGND VGND VPWR VPWR rf.registers\[25\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7715_ _3338_ _3230_ _3334_ _0961_ VGND VGND VPWR VPWR _3368_ sky130_fd_sc_hd__o211a_1
X_7646_ _3290_ _3297_ VGND VGND VPWR VPWR _3301_ sky130_fd_sc_hd__xnor2_1
X_4858_ _0303_ _0542_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_530 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7577_ net64 _3230_ VGND VGND VPWR VPWR _3232_ sky130_fd_sc_hd__nand2_1
X_4789_ _0317_ _4266_ _0316_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__or3_1
X_6528_ _1997_ _1998_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__nor2_1
X_6459_ _0647_ _2117_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_42_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_8129_ _3773_ _3732_ _3779_ _3781_ VGND VGND VPWR VPWR _3782_ sky130_fd_sc_hd__a211o_4
XFILLER_0_100_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5830_ _1488_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__inv_2
X_5761_ _1419_ _1371_ _1380_ _1418_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__or4_4
X_8480_ net225 _4045_ VGND VGND VPWR VPWR _4052_ sky130_fd_sc_hd__and2_1
X_4712_ _0407_ _4275_ net59 VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7500_ _0494_ _3152_ VGND VGND VPWR VPWR _3155_ sky130_fd_sc_hd__and2b_1
X_7431_ _3078_ _3083_ _3087_ VGND VGND VPWR VPWR _3088_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_60_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5692_ _1346_ _1245_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_32_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4643_ _0336_ _0338_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4574_ _0230_ _0270_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__nand2_1
X_7362_ _2970_ _3001_ _2992_ VGND VGND VPWR VPWR _3019_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6313_ _1875_ _1880_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__and2_1
X_7293_ _2933_ _2940_ _2949_ _2935_ VGND VGND VPWR VPWR _2950_ sky130_fd_sc_hd__a2bb2o_1
X_6244_ _1758_ _1884_ _1837_ _1818_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__a2bb2o_1
X_6175_ _1798_ _1833_ _1822_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__mux2_1
X_5126_ _0648_ _0772_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__nor2_1
X_5057_ _0713_ _0701_ _0715_ _0624_ _0699_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_68_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8816_ clknet_4_10_0_clk _0190_ VGND VGND VPWR VPWR rf.registers\[5\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_80_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5959_ _0660_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__buf_4
X_8747_ clknet_4_0_0_clk _0121_ VGND VGND VPWR VPWR rf.registers\[15\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8678_ _4140_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_105_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7629_ _3278_ _3281_ VGND VGND VPWR VPWR _3284_ sky130_fd_sc_hd__xor2_1
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold73 rf.registers\[5\]\[1\] VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 display.refresh_counter\[12\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 display.refresh_counter\[5\] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 rf.registers\[15\]\[9\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 rf.registers\[10\]\[12\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_100_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_4 _2296_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer27 _3726_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__buf_6
X_7980_ _2396_ _3632_ VGND VGND VPWR VPWR _3633_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_65_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6931_ _2388_ _2587_ VGND VGND VPWR VPWR _2588_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_37_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6862_ _2493_ _2497_ _2515_ _2517_ _0694_ VGND VGND VPWR VPWR _2519_ sky130_fd_sc_hd__a311oi_2
XFILLER_0_76_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5813_ _1469_ _1471_ _1456_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__mux2_4
X_8601_ net246 _4094_ VGND VGND VPWR VPWR _4100_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_6793_ _2429_ _2432_ _2422_ _2428_ VGND VGND VPWR VPWR _2450_ sky130_fd_sc_hd__a211oi_1
X_8532_ _4070_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__inv_2
XFILLER_0_84_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5744_ net15 _0629_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__nand2_1
X_8463_ net173 _4034_ VGND VGND VPWR VPWR _4043_ sky130_fd_sc_hd__and2_1
X_5675_ _1333_ _1325_ net264 VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_7414_ _0587_ _3070_ VGND VGND VPWR VPWR _3071_ sky130_fd_sc_hd__xor2_1
X_8394_ net235 _0582_ _3997_ VGND VGND VPWR VPWR _4006_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4626_ _4248_ _4251_ _0322_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__a21oi_1
X_7345_ _2970_ _3001_ VGND VGND VPWR VPWR _3002_ sky130_fd_sc_hd__xnor2_2
X_4557_ _0252_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_77_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4488_ _4292_ _4296_ VGND VGND VPWR VPWR _4297_ sky130_fd_sc_hd__nor2_1
X_7276_ _2903_ _2911_ _2931_ _2932_ VGND VGND VPWR VPWR _2933_ sky130_fd_sc_hd__o31a_1
X_6227_ _1741_ _1885_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__xnor2_1
X_6158_ _1679_ _1816_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__nor2_1
X_5109_ _0656_ _0742_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__nand2_1
X_6089_ _0636_ _1630_ _1737_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput6 net6 VGND VGND VPWR VPWR an[4] sky130_fd_sc_hd__clkbuf_4
Xoutput41 net41 VGND VGND VPWR VPWR result[9] sky130_fd_sc_hd__clkbuf_4
Xoutput30 net61 VGND VGND VPWR VPWR result[28] sky130_fd_sc_hd__buf_2
XFILLER_0_101_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5460_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__inv_2
XFILLER_0_78_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4411_ _4217_ _4218_ _4219_ VGND VGND VPWR VPWR _4220_ sky130_fd_sc_hd__or3_1
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5391_ _1033_ _1048_ _1049_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__a21oi_1
X_4342_ imem.address\[1\] imem.address\[0\] imem.address\[2\] VGND VGND VPWR VPWR
+ _4151_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7130_ _2760_ _2763_ _2774_ _2776_ VGND VGND VPWR VPWR _2787_ sky130_fd_sc_hd__o31a_1
X_7061_ _2683_ _2687_ VGND VGND VPWR VPWR _2718_ sky130_fd_sc_hd__or2_1
X_6012_ _1329_ _1552_ _1558_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__and3_1
.ends
